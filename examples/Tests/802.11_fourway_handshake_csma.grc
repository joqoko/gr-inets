<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>csma_rtscts_80211</value></param>
<param><key>author</key><value>PWA</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>csma_rtscts_80211</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cs_threshold</value></param>
<param><key>value</key><value>0.005</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_address</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>diff_preamble_128</value></param>
<param><key>value</key><value>[1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0,0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0,0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1,1, 1, 1, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 1, 0, 0][0:128]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mu</value></param>
<param><key>value</key><value>0.6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>padding</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_center_frequency</value></param>
<param><key>value</key><value>3.9e8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>400000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_address</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>system_time_granularity_us</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timeout_duration_ms</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_center_frequency</value></param>
<param><key>value</key><value>4e8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_device_address</value></param>
<param><key>value</key><value>"addr=10.0.0.6"</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import gnuradio</value></param>
</block>
<block>
<key>inets_address_check</key>
<param><key>id</key><value>inets_address_check_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>my_address</key><value>source_address</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
<param><key>show_not_pass</key><value>0</value></param>
</block>
<block>
<key>inets_backoff</key>
<param><key>id</key><value>inets_backoff_0</value></param>
<param><key>apply_cs</key><value>1</value></param>
<param><key>backoff_time_unit_ms</key><value>5</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>virtual_cs</key><value>1</value></param>
<param><key>max_backoff_ms</key><value>400</value></param>
<param><key>min_backoff_ms</key><value>10</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>cs_threshold</key><value>0.005</value></param>
<param><key>backoff_type</key><value>1</value></param>
</block>
<block>
<key>inets_backoff</key>
<param><key>id</key><value>inets_backoff_1</value></param>
<param><key>apply_cs</key><value>1</value></param>
<param><key>backoff_time_unit_ms</key><value>10</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>virtual_cs</key><value>1</value></param>
<param><key>max_backoff_ms</key><value>100</value></param>
<param><key>min_backoff_ms</key><value>50</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>cs_threshold</key><value>0.005</value></param>
<param><key>backoff_type</key><value>3</value></param>
</block>
<block>
<key>inets_carrier_sensing</key>
<param><key>id</key><value>inets_carrier_sensing_0</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>nf_initial_n</key><value>100</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>cs_duration</key><value>100</value></param>
<param><key>cs_mode</key><value>4</value></param>
<param><key>show_fail</key><value>0</value></param>
<param><key>show_stop</key><value>0</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>cs_threshold</key><value>0.005</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0</value></param>
<param><key>develop_mode</key><value>2</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>2</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"good_frame"</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>1</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"tx_rts"</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>10</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"acked"</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_1</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>1</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"tx_data"</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_1_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>1</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"tx_cts"</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_1_0_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>1</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"rx_cts"</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_1_0_0_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>1</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"rx_rts"</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_1_0_0_0_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>1</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"rx_ack"</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_1_0_0_0_0_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>1</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"rx_data"</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_1_1</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>1</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"tx_ack"</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_1</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>2</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"bad_frame"</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_1_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>2</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"bad_frame"</value></param>
</block>
<block>
<key>inets_cts_framing</key>
<param><key>id</key><value>inets_cts_framing_0</value></param>
<param><key>block_id</key><value>31</value></param>
<param><key>default_ifs_setting</key><value>default</value></param>
<param><key>default_PHY_setting</key><value>default</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>destination_address</key><value>destination_address</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>len_rts_cts_payload</key><value>3</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>output_frame_pmt</key><value>1</value></param>
<param><key>padding</key><value>padding</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>reserved_field_I</key><value>318</value></param>
<param><key>reserved_field_II</key><value>524</value></param>
<param><key>SIFS</key><value>1000</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>slot_time</key><value>800</value></param>
<param><key>source_address</key><value>source_address</value></param>
<param><key>bps</key><value>gnuradio.digital.constellation_qpsk().bits_per_symbol() * (samp_rate / sps)</value></param>
</block>
<block>
<key>inets_dummy_source</key>
<param><key>id</key><value>inets_dummy_source_0</value></param>
<param><key>block_id</key><value>23</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>packet_rate</key><value>1</value></param>
<param><key>payload_length</key><value>837</value></param>
<param><key>show</key><value>1</value></param>
<param><key>source_type</key><value>3</value></param>
</block>
<block>
<key>inets_frame_analysis</key>
<param><key>id</key><value>inets_frame_analysis_0</value></param>
<param><key>apply_self_address_check</key><value>1</value></param>
<param><key>block_id</key><value>7</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>my_address</key><value>source_address</value></param>
</block>
<block>
<key>inets_frame_buffer</key>
<param><key>id</key><value>inets_frame_buffer_0</value></param>
<param><key>auto_dequeue_first</key><value>1</value></param>
<param><key>auto_dequeue_full</key><value>0</value></param>
<param><key>block_id</key><value>16</value></param>
<param><key>buffer_size</key><value>1000</value></param>
<param><key>keep_dequeue_state</key><value>1</value></param>
<param><key>dequeue</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>enqueue</key><value>0</value></param>
<param><key>flush</key><value>1</value></param>
<param><key>show_empty</key><value>1</value></param>
<param><key>show_full</key><value>1</value></param>
<param><key>indicate</key><value>1</value></param>
<param><key>output_empty</key><value>1</value></param>
</block>
<block>
<key>inets_frame_buffer</key>
<param><key>id</key><value>inets_frame_buffer_1</value></param>
<param><key>auto_dequeue_first</key><value>1</value></param>
<param><key>auto_dequeue_full</key><value>1</value></param>
<param><key>block_id</key><value>16</value></param>
<param><key>buffer_size</key><value>10</value></param>
<param><key>keep_dequeue_state</key><value>1</value></param>
<param><key>dequeue</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>enqueue</key><value>0</value></param>
<param><key>flush</key><value>1</value></param>
<param><key>show_empty</key><value>1</value></param>
<param><key>show_full</key><value>1</value></param>
<param><key>indicate</key><value>1</value></param>
<param><key>output_empty</key><value>1</value></param>
</block>
<block>
<key>inets_frame_check</key>
<param><key>id</key><value>inets_frame_check_0</value></param>
<param><key>block_id</key><value>9</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_bad_frame</key><value>0</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_1</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_1_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_1_0_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_1_0_0_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_1_0_0_0_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_1_0_0_0_1</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_1_0_0_0_1_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_1_0_1</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_type_check</key>
<param><key>id</key><value>inets_frame_type_check_0</value></param>
<param><key>ack_frame</key><value>0</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>ampdu_subframe</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>amsdu_subframe</key><value>1</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>block_id</key><value>25</value></param>
<param><key>cts_frame</key><value>0</value></param>
<param><key>data_frame</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>other_frame</key><value>1</value></param>
<param><key>rts_frame</key><value>0</value></param>
</block>
<block>
<key>inets_frame_type_check</key>
<param><key>id</key><value>inets_frame_type_check_0_0</value></param>
<param><key>ack_frame</key><value>0</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>ampdu_subframe</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>amsdu_subframe</key><value>1</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>block_id</key><value>25</value></param>
<param><key>cts_frame</key><value>1</value></param>
<param><key>data_frame</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>other_frame</key><value>1</value></param>
<param><key>rts_frame</key><value>1</value></param>
</block>
<block>
<key>inets_frame_type_check</key>
<param><key>id</key><value>inets_frame_type_check_0_0_0</value></param>
<param><key>ack_frame</key><value>1</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>ampdu_subframe</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>amsdu_subframe</key><value>1</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>block_id</key><value>25</value></param>
<param><key>cts_frame</key><value>0</value></param>
<param><key>data_frame</key><value>1</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>other_frame</key><value>1</value></param>
<param><key>rts_frame</key><value>0</value></param>
</block>
<block>
<key>inets_frame_type_check</key>
<param><key>id</key><value>inets_frame_type_check_0_0_1</value></param>
<param><key>ack_frame</key><value>1</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>ampdu_subframe</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>amsdu_subframe</key><value>1</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>block_id</key><value>25</value></param>
<param><key>cts_frame</key><value>1</value></param>
<param><key>data_frame</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>other_frame</key><value>1</value></param>
<param><key>rts_frame</key><value>0</value></param>
</block>
<block>
<key>inets_frame_type_check</key>
<param><key>id</key><value>inets_frame_type_check_0_1</value></param>
<param><key>ack_frame</key><value>1</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>ampdu_subframe</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>amsdu_subframe</key><value>1</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>block_id</key><value>25</value></param>
<param><key>cts_frame</key><value>0</value></param>
<param><key>data_frame</key><value>1</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>other_frame</key><value>1</value></param>
<param><key>rts_frame</key><value>0</value></param>
</block>
<block>
<key>inets_framing</key>
<param><key>id</key><value>inets_framing_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>default_payload_length</key><value>300</value></param>
<param><key>destination_address</key><value>destination_address</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>frame_type</key><value>1</value></param>
<param><key>increase_index</key><value>1</value></param>
<param><key>frame_index</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_slot_time_beacon</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>node_list</key><value>[2, 3]</value></param>
<param><key>output_frame_pmt</key><value>1</value></param>
<param><key>reserved_field_I</key><value>318</value></param>
<param><key>reserved_field_II</key><value>524</value></param>
<param><key>reserved_field_ampdu</key><value>0</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>show_reset_index</key><value>1</value></param>
<param><key>slot_list_ms</key><value>[1000, 1000]</value></param>
<param><key>source_address</key><value>source_address</value></param>
<param><key>default_payload</key><value>0</value></param>
<param><key>internal_index</key><value>1</value></param>
</block>
<block>
<key>inets_framing</key>
<param><key>id</key><value>inets_framing_0_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>default_payload_length</key><value>300</value></param>
<param><key>destination_address</key><value>destination_address</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>frame_type</key><value>2</value></param>
<param><key>increase_index</key><value>1</value></param>
<param><key>frame_index</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_slot_time_beacon</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>node_list</key><value>[2, 3]</value></param>
<param><key>output_frame_pmt</key><value>1</value></param>
<param><key>reserved_field_I</key><value>318</value></param>
<param><key>reserved_field_II</key><value>524</value></param>
<param><key>reserved_field_ampdu</key><value>0</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>show_reset_index</key><value>1</value></param>
<param><key>slot_list_ms</key><value>[1000, 1000]</value></param>
<param><key>source_address</key><value>source_address</value></param>
<param><key>default_payload</key><value>0</value></param>
<param><key>internal_index</key><value>1</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_0</value></param>
<param><key>block_id</key><value>3</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>200</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>0</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>3</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_0_0</value></param>
<param><key>block_id</key><value>1</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>1000000</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_0_1</value></param>
<param><key>block_id</key><value>3</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>18</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_0_1_0</value></param>
<param><key>block_id</key><value>3</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>8</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>inets_receiving</key>
<param><key>id</key><value>inets_receiving_0</value></param>
<param><key>block_id</key><value>21</value></param>
<param><key>center_frequency</key><value>rx_center_frequency</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>reset_rf</key><value>1</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>mu</key><value>mu</value></param>
<param><key>output_rss</key><value>0</value></param>
<param><key>output_rx_switch</key><value>1</value></param>
<param><key>output_snr</key><value>1</value></param>
<param><key>output_rx_frame</key><value>0</value></param>
<param><key>rx_gain</key><value>rx_gain</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold</key><value>30</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>matched_filter_coeff</key><value>rrc</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>usrp_device_address</key><value>usrp_device_address</value></param>
</block>
<block>
<key>inets_resend_check</key>
<param><key>id</key><value>inets_resend_check_0</value></param>
<param><key>block_id</key><value>24</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>max_resend</key><value>6</value></param>
</block>
<block>
<key>inets_rts_framing</key>
<param><key>id</key><value>inets_rts_framing_0</value></param>
<param><key>block_id</key><value>30</value></param>
<param><key>default_ifs_setting</key><value>default</value></param>
<param><key>default_PHY_setting</key><value>default</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>destination_address</key><value>destination_address</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>len_rts_cts_payload</key><value>3</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>output_frame_pmt</key><value>1</value></param>
<param><key>padding</key><value>padding</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>reserved_field_I</key><value>318</value></param>
<param><key>reserved_field_II</key><value>524</value></param>
<param><key>SIFS</key><value>1000</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>slot_time</key><value>800</value></param>
<param><key>source_address</key><value>source_address</value></param>
<param><key>bps</key><value>gnuradio.digital.constellation_qpsk().bits_per_symbol() * (samp_rate / sps)</value></param>
</block>
<block>
<key>inets_run</key>
<param><key>id</key><value>inets_run_0</value></param>
<param><key>start_next_time_s</key><value>5</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
</block>
<block>
<key>inets_sending</key>
<param><key>id</key><value>inets_sending_0</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>center_frequency</key><value>tx_center_frequency</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>interframe_interval_s</key><value>0.005</value></param>
<param><key>file_name_extension_pending</key><value>"Tfr"</value></param>
<param><key>file_name_extension_t_control</key><value>"t1TXs"</value></param>
<param><key>name_with_timestamp</key><value>0</value></param>
<param><key>t_pretx_interval_s</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>ack_frame</key><value>0</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>cts_frame</key><value>0</value></param>
<param><key>data_frame</key><value>0</value></param>
<param><key>rts_frame</key><value>0</value></param>
<param><key>rx_control</key><value>0</value></param>
<param><key>unknown_frame</key><value>1</value></param>
<param><key>tx_gain</key><value>0</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>usrp_device_address</key><value>usrp_device_address</value></param>
</block>
<block>
<key>inets_timeout</key>
<param><key>id</key><value>inets_timeout_0</value></param>
<param><key>block_id</key><value>10</value></param>
<param><key>data_ack</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>llc_protocol</key><value>0</value></param>
<param><key>rts_cts</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>1000</value></param>
<param><key>timeout_duration_ms</key><value>100</value></param>
</block>
<block>
<key>inets_timeout</key>
<param><key>id</key><value>inets_timeout_0_0</value></param>
<param><key>block_id</key><value>10</value></param>
<param><key>data_ack</key><value>1</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>llc_protocol</key><value>0</value></param>
<param><key>rts_cts</key><value>0</value></param>
<param><key>system_time_granularity_us</key><value>1000</value></param>
<param><key>timeout_duration_ms</key><value>100</value></param>
</block>
<block>
<key>inets_virtual_cs</key>
<param><key>id</key><value>inets_virtual_cs_0</value></param>
<param><key>block_id</key><value>20</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
</block>
<connection><source_block_id>inets_address_check_0</source_block_id><sink_block_id>inets_counter_0_1_0</sink_block_id><source_key>address_check_fail_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_address_check_0</source_block_id><sink_block_id>inets_frame_type_check_0_1</sink_block_id><source_key>address_check_fail_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_address_check_0</source_block_id><sink_block_id>inets_frame_type_check_0</sink_block_id><source_key>address_check_pass_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_backoff_0</source_block_id><sink_block_id>inets_resend_check_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_backoff_1</source_block_id><sink_block_id>inets_counter_0_0_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_backoff_1</source_block_id><sink_block_id>inets_frame_buffer_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>dequeue</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0</source_block_id><sink_block_id>inets_backoff_0</sink_block_id><source_key>frame_info_fail_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0</source_block_id><sink_block_id>inets_frame_buffer_1</sink_block_id><source_key>frame_info_pass_out</source_key><sink_key>enqueue</sink_key></connection>
<connection><source_block_id>inets_cts_framing_0</source_block_id><sink_block_id>inets_general_timer_0_1_0</sink_block_id><source_key>frame_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_dummy_source_0</source_block_id><sink_block_id>inets_framing_0</sink_block_id><source_key>output</source_key><sink_key>data_in</sink_key></connection>
<connection><source_block_id>inets_frame_analysis_0</source_block_id><sink_block_id>inets_frame_check_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_buffer_0</source_block_id><sink_block_id>inets_rts_framing_0</sink_block_id><source_key>dequeue_element</source_key><sink_key>data_frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_buffer_1</source_block_id><sink_block_id>inets_sending_0</sink_block_id><source_key>dequeue_element</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_frame_check_0</source_block_id><sink_block_id>inets_counter_0_1</sink_block_id><source_key>bad_frame_info_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_frame_check_0</source_block_id><sink_block_id>inets_address_check_0</sink_block_id><source_key>good_frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_check_0</source_block_id><sink_block_id>inets_counter_0</sink_block_id><source_key>good_frame_info_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_1</source_block_id><sink_block_id>inets_general_timer_0</sink_block_id><source_key>frame_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_0</source_block_id><sink_block_id>inets_carrier_sensing_0</sink_block_id><source_key>frame_out</source_key><sink_key>info_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_0</source_block_id><sink_block_id>inets_general_timer_0_1</sink_block_id><source_key>frame_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_0_0</source_block_id><sink_block_id>inets_frame_buffer_1</sink_block_id><source_key>frame_out</source_key><sink_key>enqueue</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_0_0_0</source_block_id><sink_block_id>inets_frame_buffer_1</sink_block_id><source_key>frame_out</source_key><sink_key>dequeue</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_0_0_0_0</source_block_id><sink_block_id>inets_timeout_0</sink_block_id><source_key>frame_out</source_key><sink_key>ack_frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_0_0_0_1</source_block_id><sink_block_id>inets_counter_0_0_1_0_0</sink_block_id><source_key>frame_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_0_0_0_1</source_block_id><sink_block_id>inets_timeout_0_0</sink_block_id><source_key>frame_out</source_key><sink_key>cts_frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_0_0_0_1_0</source_block_id><sink_block_id>inets_rts_framing_0</sink_block_id><source_key>frame_out</source_key><sink_key>cts_frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_0_1</source_block_id><sink_block_id>inets_backoff_0</sink_block_id><source_key>frame_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0</source_block_id><sink_block_id>inets_counter_0_0_1_0_0_0_0</sink_block_id><source_key>ack_frame_info_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0</source_block_id><sink_block_id>inets_frame_path_1_0_0_0_0</sink_block_id><source_key>ack_frame_info_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0</source_block_id><sink_block_id>inets_frame_path_1_0_0_0_1</sink_block_id><source_key>cts_frame_info_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0</source_block_id><sink_block_id>inets_counter_0_0_1_0_0_0_0_0</sink_block_id><source_key>data_frame_info_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0</source_block_id><sink_block_id>inets_framing_0_0</sink_block_id><source_key>data_frame_info_out</source_key><sink_key>data_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0</source_block_id><sink_block_id>inets_counter_0_0_1_0_0_0</sink_block_id><source_key>rts_frame_info_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0</source_block_id><sink_block_id>inets_cts_framing_0</sink_block_id><source_key>rts_frame_info_out</source_key><sink_key>rts_frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0</source_block_id><sink_block_id>inets_virtual_cs_0</sink_block_id><source_key>rts_frame_info_out</source_key><sink_key>nav_cmd_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0_0</source_block_id><sink_block_id>inets_backoff_1</sink_block_id><source_key>ack_frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0_0</source_block_id><sink_block_id>inets_rts_framing_0</sink_block_id><source_key>data_frame_info_out</source_key><sink_key>data_frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0_0_0</source_block_id><sink_block_id>inets_frame_path_1_0_0_0_1_0</sink_block_id><source_key>cts_frame_info_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0_0_0</source_block_id><sink_block_id>inets_frame_path_1_0_1</sink_block_id><source_key>rts_frame_info_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0_0_1</source_block_id><sink_block_id>inets_general_timer_0_1_0</sink_block_id><source_key>data_frame_info_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0_0_1</source_block_id><sink_block_id>inets_virtual_cs_0</sink_block_id><source_key>rts_frame_info_out</source_key><sink_key>frame_cmd_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0_1</source_block_id><sink_block_id>inets_virtual_cs_0</sink_block_id><source_key>cts_frame_info_out</source_key><sink_key>nav_cmd_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0_1</source_block_id><sink_block_id>inets_virtual_cs_0</sink_block_id><source_key>rts_frame_info_out</source_key><sink_key>nav_cmd_in</sink_key></connection>
<connection><source_block_id>inets_framing_0</source_block_id><sink_block_id>inets_frame_buffer_0</sink_block_id><source_key>frame_out</source_key><sink_key>enqueue</sink_key></connection>
<connection><source_block_id>inets_framing_0_0</source_block_id><sink_block_id>inets_general_timer_0_1_0</sink_block_id><source_key>frame_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_0</source_block_id><sink_block_id>inets_dummy_source_0</sink_block_id><source_key>expire_signal_out</source_key><sink_key>trigger</sink_key></connection>
<connection><source_block_id>inets_general_timer_0</source_block_id><sink_block_id>inets_frame_path_1</sink_block_id><source_key>expire_signal_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_0_0</source_block_id><sink_block_id>inets_general_timer_0</sink_block_id><source_key>expire_signal_out</source_key><sink_key>disable_timer_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_0_1</source_block_id><sink_block_id>inets_carrier_sensing_0</sink_block_id><source_key>expire_signal_out</source_key><sink_key>stop_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_0_1_0</source_block_id><sink_block_id>inets_frame_path_1_0_0</sink_block_id><source_key>expire_signal_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0</source_block_id><sink_block_id>inets_frame_analysis_0</sink_block_id><source_key>rx_frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0</source_block_id><sink_block_id>inets_carrier_sensing_0</sink_block_id><source_key>rx_power_out</source_key><sink_key>power_in</sink_key></connection>
<connection><source_block_id>inets_resend_check_0</source_block_id><sink_block_id>inets_frame_buffer_0</sink_block_id><source_key>resend_check_fail_out</source_key><sink_key>dequeue</sink_key></connection>
<connection><source_block_id>inets_resend_check_0</source_block_id><sink_block_id>inets_frame_path_1_0</sink_block_id><source_key>resend_check_pass_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_rts_framing_0</source_block_id><sink_block_id>inets_frame_type_check_0_0_1</sink_block_id><source_key>frame_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_run_0</source_block_id><sink_block_id>inets_general_timer_0</sink_block_id><source_key>trigger_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_run_0</source_block_id><sink_block_id>inets_general_timer_0_0</sink_block_id><source_key>trigger_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_sending_0</source_block_id><sink_block_id>inets_counter_0_0_1_1</sink_block_id><source_key>ack_frame_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_sending_0</source_block_id><sink_block_id>inets_counter_0_0_1_0</sink_block_id><source_key>cts_frame_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_sending_0</source_block_id><sink_block_id>inets_counter_0_0_1</sink_block_id><source_key>data_frame_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_sending_0</source_block_id><sink_block_id>inets_timeout_0</sink_block_id><source_key>data_frame_out</source_key><sink_key>data_frame_info_in</sink_key></connection>
<connection><source_block_id>inets_sending_0</source_block_id><sink_block_id>inets_counter_0_0</sink_block_id><source_key>rts_frame_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_sending_0</source_block_id><sink_block_id>inets_timeout_0_0</sink_block_id><source_key>rts_frame_out</source_key><sink_key>rts_frame_info_in</sink_key></connection>
<connection><source_block_id>inets_sending_0</source_block_id><sink_block_id>inets_frame_path_1_0_0_0</sink_block_id><source_key>rx_control_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_timeout_0</source_block_id><sink_block_id>inets_frame_type_check_0_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_timeout_0_0</source_block_id><sink_block_id>inets_frame_type_check_0_0_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_virtual_cs_0</source_block_id><sink_block_id>inets_frame_path_1_0</sink_block_id><source_key>frame_cmd_out</source_key><sink_key>frame_in</sink_key></connection>
</flow_graph>
