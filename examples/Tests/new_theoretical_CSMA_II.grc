<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>new_theoretical_CSMA_II</value></param>
<param><key>author</key><value>PWA</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>new_theoretical_CSMA_II</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Single_rxp_time_s</value></param>
<param><key>value</key><value>500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cs_threshold</value></param>
<param><key>value</key><value>0.001</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_address</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>diff_preamble_128</value></param>
<param><key>value</key><value>[1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0,0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0,0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1,1, 1, 1, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 1, 0, 0][0:128]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mu</value></param>
<param><key>value</key><value>0.6</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_center_frequency</value></param>
<param><key>value</key><value>4.3e8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>400000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>slot_time</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_address</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>system_time_granularity_us</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timeout_duration_ms</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_center_frequency</value></param>
<param><key>value</key><value>4.3e8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_device_address</value></param>
<param><key>value</key><value>"addr=10.0.0.6"</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import gnuradio</value></param>
</block>
<block>
<key>inets_carrier_sensing</key>
<param><key>id</key><value>inets_carrier_sensing_0</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>rx_sensitivity_dB</key><value>20</value></param>
<param><key>nf_initial_n</key><value>-1</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>cs_duration</key><value>100</value></param>
<param><key>cs_mode</key><value>3</value></param>
<param><key>show_fail</key><value>1</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>show_stop</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>cs_threshold</key><value>cs_threshold</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0_0</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_1</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_switch</key>
<param><key>id</key><value>inets_cmd_switch_0</value></param>
<param><key>block_id</key><value>47</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>1</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"tx_frame"</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>name_with_stamp</key><value>0</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_0_0</value></param>
<param><key>develop_mode</key><value>3</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>1</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"sent_3"</value></param>
<param><key>record_on</key><value>1</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>name_with_stamp</key><value>0</value></param>
</block>
<block>
<key>inets_dummy_source</key>
<param><key>id</key><value>inets_dummy_source_0</value></param>
<param><key>block_id</key><value>23</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>packet_rate</key><value>1</value></param>
<param><key>payload_length</key><value>770</value></param>
<param><key>show</key><value>1</value></param>
<param><key>source_type</key><value>3</value></param>
</block>
<block>
<key>inets_frame_counter</key>
<param><key>id</key><value>inets_frame_counter_0</value></param>
<param><key>block_id</key><value>36</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>counts</key><value>15</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>set</key><value>1</value></param>
<param><key>unselect</key><value>0</value></param>
</block>
<block>
<key>inets_frame_counter</key>
<param><key>id</key><value>inets_frame_counter_0_0</value></param>
<param><key>block_id</key><value>36</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>counts</key><value>3</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>set</key><value>1</value></param>
<param><key>unselect</key><value>0</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_0</value></param>
<param><key>block_id</key><value>100</value></param>
<param><key>cs_threshold</key><value>0.001</value></param>
<param><key>cs_mode</key><value>1</value></param>
<param><key>develop_mode</key><value>2</value></param>
<param><key>file_name_extension</key><value>""</value></param>
<param><key>output_time_info</key><value>1</value></param>
<param><key>print_frame</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_framing</key>
<param><key>id</key><value>inets_framing_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>default_payload_length</key><value>300</value></param>
<param><key>destination_address</key><value>destination_address</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>frame_type</key><value>1</value></param>
<param><key>increase_index</key><value>1</value></param>
<param><key>frame_index</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_slot_time_beacon</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>node_list</key><value>[2, 3]</value></param>
<param><key>output_frame_pmt</key><value>1</value></param>
<param><key>reserved_field_I</key><value>318</value></param>
<param><key>reserved_field_II</key><value>524</value></param>
<param><key>reserved_field_ampdu</key><value>0</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>show_reset_index</key><value>1</value></param>
<param><key>slot_list_ms</key><value>[1000, 1000]</value></param>
<param><key>source_address</key><value>source_address</value></param>
<param><key>default_payload</key><value>0</value></param>
<param><key>internal_index</key><value>1</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_0</value></param>
<param><key>block_id</key><value>5</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>Single_rxp_time_s * 1000</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_1</value></param>
<param><key>block_id</key><value>5</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>slot_time</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>0</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>inets_parameter_list</key>
<param><key>id</key><value>inets_parameter_list_0</value></param>
<param><key>block_id</key><value>49</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>list</key><value>[1, 0.761405872543967,   0.461816006183166,   0.280105566896129, 0.169892614278690,   0.103045079418758 ,  0.062500000000000, 0.037908166232040, 0.022992465073215,   0.013945635009277, 0.008458455202288,   0.005130312413994, 0.003111691772991 , 0.001887336463895,   0.001144727430546, 1, 1, 0.923632012366331,0.560211133792258, 0.339785228557381, 0.206090158837516, 0.125, 0.075816332464079, 0.045984930146430 , 0.027891270018554, 0.016916910404577, 0.010260624827987 ,0.006223383545983, 0.00377467292779, 0.002289454861092, 1, 1, 1, 0.746948178389677, 0.453046971409841, 0.274786878450021, 0.166666666666667, 0.101088443285439, 0.061313240195240, 0.037188360024738, 0.022555880539435, 0.013680833103983, 0.008297844727977, 0.005032897237053, 0.003052606481456]</value></param>
</block>
<block>
<key>inets_parameter_list</key>
<param><key>id</key><value>inets_parameter_list_0_0</value></param>
<param><key>block_id</key><value>49</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>list</key><value>[13.3333, 10, 5]</value></param>
</block>
<block>
<key>inets_random_filter</key>
<param><key>id</key><value>inets_random_filter_0</value></param>
<param><key>block_id</key><value>3</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>lose</key><value>1</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>threshold</key><value>0.95</value></param>
</block>
<block>
<key>inets_random_filter</key>
<param><key>id</key><value>inets_random_filter_0_0</value></param>
<param><key>block_id</key><value>3</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>lose</key><value>0</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>threshold</key><value>0.03</value></param>
</block>
<block>
<key>inets_receiving</key>
<param><key>id</key><value>inets_receiving_0</value></param>
<param><key>block_id</key><value>21</value></param>
<param><key>center_frequency</key><value>rx_center_frequency</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>reset_rf</key><value>0</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>mu</key><value>mu</value></param>
<param><key>output_rss</key><value>0</value></param>
<param><key>output_rx_switch</key><value>0</value></param>
<param><key>output_snr</key><value>1</value></param>
<param><key>output_rx_frame</key><value>1</value></param>
<param><key>rx_gain</key><value>rx_gain</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold</key><value>30</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>matched_filter_coeff</key><value>rrc</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>usrp_device_address</key><value>usrp_device_address</value></param>
</block>
<block>
<key>inets_run</key>
<param><key>id</key><value>inets_run_0</value></param>
<param><key>start_next_time_s</key><value>20</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
</block>
<block>
<key>inets_sending</key>
<param><key>id</key><value>inets_sending_0</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>center_frequency</key><value>tx_center_frequency</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>interframe_interval_s</key><value>0.004</value></param>
<param><key>file_name_extension_pending</key><value>"Tfr"</value></param>
<param><key>file_name_extension_t_control</key><value>"t1TXs"</value></param>
<param><key>name_with_timestamp</key><value>1</value></param>
<param><key>t_pretx_interval_s</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>ack_frame</key><value>1</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>cts_frame</key><value>1</value></param>
<param><key>data_frame</key><value>0</value></param>
<param><key>rts_frame</key><value>1</value></param>
<param><key>rx_control</key><value>0</value></param>
<param><key>unknown_frame</key><value>1</value></param>
<param><key>tx_gain</key><value>0</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>usrp_device_address</key><value>usrp_device_address</value></param>
</block>
<block>
<key>inets_standard_timer</key>
<param><key>id</key><value>inets_standard_timer_0</value></param>
<param><key>block_id</key><value>51</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration</key><value>slot_time</value></param>
<param><key>disable_timer</key><value>0</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reset_duration</key><value>0</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
</block>
<connection><source_block_id>inets_carrier_sensing_0</source_block_id><sink_block_id>inets_random_filter_0_0</sink_block_id><source_key>cmd_pass_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0</source_block_id><sink_block_id>inets_counter_0_0_0_0</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_counter</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0</source_block_id><sink_block_id>inets_standard_timer_0</sink_block_id><source_key>cmd_out</source_key><sink_key>disable_timer_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0</source_block_id><sink_block_id>inets_cmd_switch_0</sink_block_id><source_key>cmd_out</source_key><sink_key>switch_on</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0_0</source_block_id><sink_block_id>inets_counter_0_0_0_0</sink_block_id><source_key>cmd_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_1</source_block_id><sink_block_id>inets_general_timer_0</sink_block_id><source_key>cmd_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_1</source_block_id><sink_block_id>inets_parameter_list_0_0</sink_block_id><source_key>cmd_out</source_key><sink_key>trigger_in</sink_key></connection>
<connection><source_block_id>inets_cmd_switch_0</source_block_id><sink_block_id>inets_random_filter_0</sink_block_id><source_key>cmd_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_dummy_source_0</source_block_id><sink_block_id>inets_framing_0</sink_block_id><source_key>output</source_key><sink_key>data_in</sink_key></connection>
<connection><source_block_id>inets_frame_counter_0</source_block_id><sink_block_id>inets_frame_counter_0_0</sink_block_id><source_key>select_out</source_key><sink_key>counts_in</sink_key></connection>
<connection><source_block_id>inets_frame_counter_0</source_block_id><sink_block_id>inets_general_timer_0</sink_block_id><source_key>unselect_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_frame_counter_0</source_block_id><sink_block_id>inets_parameter_list_0</sink_block_id><source_key>unselect_out</source_key><sink_key>trigger_in</sink_key></connection>
<connection><source_block_id>inets_frame_counter_0_0</source_block_id><sink_block_id>inets_cmd_path_0</sink_block_id><source_key>select_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_frame_counter_0_0</source_block_id><sink_block_id>inets_cmd_path_0_1</sink_block_id><source_key>unselect_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_framing_0</source_block_id><sink_block_id>inets_carrier_sensing_0</sink_block_id><source_key>frame_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_0</source_block_id><sink_block_id>inets_frame_counter_0</sink_block_id><source_key>expire_signal_out</source_key><sink_key>counts_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_1</source_block_id><sink_block_id>inets_carrier_sensing_0</sink_block_id><source_key>expire_signal_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_parameter_list_0</source_block_id><sink_block_id>inets_counter_0_0_0_0</sink_block_id><source_key>parameter_out</source_key><sink_key>reset_counter</sink_key></connection>
<connection><source_block_id>inets_parameter_list_0</source_block_id><sink_block_id>inets_random_filter_0</sink_block_id><source_key>parameter_out</source_key><sink_key>set_threshold</sink_key></connection>
<connection><source_block_id>inets_parameter_list_0_0</source_block_id><sink_block_id>inets_general_timer_1</sink_block_id><source_key>parameter_out</source_key><sink_key>reset_duration_in</sink_key></connection>
<connection><source_block_id>inets_parameter_list_0_0</source_block_id><sink_block_id>inets_parameter_list_0</sink_block_id><source_key>parameter_out</source_key><sink_key>trigger_in</sink_key></connection>
<connection><source_block_id>inets_parameter_list_0_0</source_block_id><sink_block_id>inets_standard_timer_0</sink_block_id><source_key>parameter_out</source_key><sink_key>reset_duration_in</sink_key></connection>
<connection><source_block_id>inets_random_filter_0</source_block_id><sink_block_id>inets_cmd_switch_0</sink_block_id><source_key>win_cmd_out</source_key><sink_key>switch_off</sink_key></connection>
<connection><source_block_id>inets_random_filter_0</source_block_id><sink_block_id>inets_dummy_source_0</sink_block_id><source_key>win_cmd_out</source_key><sink_key>trigger</sink_key></connection>
<connection><source_block_id>inets_random_filter_0_0</source_block_id><sink_block_id>inets_general_timer_1</sink_block_id><source_key>lose_cmd_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_random_filter_0_0</source_block_id><sink_block_id>inets_cmd_path_0_0_0</sink_block_id><source_key>win_cmd_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_random_filter_0_0</source_block_id><sink_block_id>inets_receiving_0</sink_block_id><source_key>win_cmd_out</source_key><sink_key>rx_switch_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0</source_block_id><sink_block_id>inets_carrier_sensing_0</sink_block_id><source_key>rx_power_out</source_key><sink_key>power_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0</source_block_id><sink_block_id>inets_sending_0</sink_block_id><source_key>rx_switch_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_run_0</source_block_id><sink_block_id>inets_general_timer_0</sink_block_id><source_key>trigger_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_run_0</source_block_id><sink_block_id>inets_parameter_list_0_0</sink_block_id><source_key>trigger_out</source_key><sink_key>trigger_in</sink_key></connection>
<connection><source_block_id>inets_run_0</source_block_id><sink_block_id>inets_standard_timer_0</sink_block_id><source_key>trigger_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_sending_0</source_block_id><sink_block_id>inets_cmd_path_0_0</sink_block_id><source_key>data_frame_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_sending_0</source_block_id><sink_block_id>inets_counter_0_0_0</sink_block_id><source_key>data_frame_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_sending_0</source_block_id><sink_block_id>inets_receiving_0</sink_block_id><source_key>rx_control_out</source_key><sink_key>rx_switch_in</sink_key></connection>
<connection><source_block_id>inets_standard_timer_0</source_block_id><sink_block_id>inets_cmd_switch_0</sink_block_id><source_key>expire_cmd_out</source_key><sink_key>cmd_in</sink_key></connection>
</flow_graph>
