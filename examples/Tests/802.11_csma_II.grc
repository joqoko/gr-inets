<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>csma_80211_II</value></param>
<param><key>author</key><value>PWA</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>csma_80211_II</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SIFS</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Single_rxp_time_s</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cs_threshold</value></param>
<param><key>value</key><value>0.001</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_address</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>diff_preamble_128</value></param>
<param><key>value</key><value>[1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0,0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0,0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1,1, 1, 1, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 1, 0, 0][0:128]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>min_window_size</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mu</value></param>
<param><key>value</key><value>0.6</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_center_frequency</value></param>
<param><key>value</key><value>3.9e8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>400000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>slot_time</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_address</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>system_time_granularity_us</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timeout_duration_ms</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_center_frequency</value></param>
<param><key>value</key><value>3.9e8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_device_address</value></param>
<param><key>value</key><value>"addr=10.0.0.16"</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import gnuradio</value></param>
</block>
<block>
<key>inets_address_check</key>
<param><key>id</key><value>inets_address_check_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>my_address</key><value>source_address</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
<param><key>show_not_pass</key><value>1</value></param>
</block>
<block>
<key>inets_address_check</key>
<param><key>id</key><value>inets_address_check_2</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>my_address</key><value>1</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
<param><key>show_not_pass</key><value>1</value></param>
</block>
<block>
<key>inets_address_check</key>
<param><key>id</key><value>inets_address_check_2_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>my_address</key><value>2</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
<param><key>show_not_pass</key><value>1</value></param>
</block>
<block>
<key>inets_address_check</key>
<param><key>id</key><value>inets_address_check_2_0_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>my_address</key><value>2</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
<param><key>show_not_pass</key><value>1</value></param>
</block>
<block>
<key>inets_address_check</key>
<param><key>id</key><value>inets_address_check_2_1</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>my_address</key><value>3</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
<param><key>show_not_pass</key><value>1</value></param>
</block>
<block>
<key>inets_address_check</key>
<param><key>id</key><value>inets_address_check_2_1_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>my_address</key><value>3</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
<param><key>show_not_pass</key><value>1</value></param>
</block>
<block>
<key>inets_address_check</key>
<param><key>id</key><value>inets_address_check_2_2</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>my_address</key><value>4</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
<param><key>show_not_pass</key><value>1</value></param>
</block>
<block>
<key>inets_address_check</key>
<param><key>id</key><value>inets_address_check_2_2_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>my_address</key><value>4</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
<param><key>show_not_pass</key><value>1</value></param>
</block>
<block>
<key>inets_address_check</key>
<param><key>id</key><value>inets_address_check_2_3</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>my_address</key><value>1</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
<param><key>show_not_pass</key><value>1</value></param>
</block>
<block>
<key>inets_backoff</key>
<param><key>id</key><value>inets_backoff_0</value></param>
<param><key>apply_cs</key><value>0</value></param>
<param><key>backoff_time_unit_ms</key><value>slot_time</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>virtual_cs</key><value>1</value></param>
<param><key>export_bof</key><value>0</value></param>
<param><key>export_busy</key><value>0</value></param>
<param><key>max_backoff_ms</key><value>400</value></param>
<param><key>min_window_size</key><value>min_window_size</value></param>
<param><key>min_backoff_ms</key><value>slot_time</value></param>
<param><key>set_cs</key><value>0</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>cs_threshold</key><value>0.005</value></param>
<param><key>backoff_type</key><value>1</value></param>
</block>
<block>
<key>inets_backoff</key>
<param><key>id</key><value>inets_backoff_1</value></param>
<param><key>apply_cs</key><value>0</value></param>
<param><key>backoff_time_unit_ms</key><value>slot_time</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>virtual_cs</key><value>1</value></param>
<param><key>export_bof</key><value>1</value></param>
<param><key>export_busy</key><value>1</value></param>
<param><key>max_backoff_ms</key><value>100</value></param>
<param><key>min_window_size</key><value>min_window_size</value></param>
<param><key>min_backoff_ms</key><value>slot_time</value></param>
<param><key>set_cs</key><value>0</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>cs_threshold</key><value>0.005</value></param>
<param><key>backoff_type</key><value>1</value></param>
</block>
<block>
<key>inets_carrier_sensing</key>
<param><key>id</key><value>inets_carrier_sensing_0</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>rx_sensitivity_dB</key><value>5</value></param>
<param><key>nf_initial_n</key><value>100</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>cs_duration</key><value>100</value></param>
<param><key>cs_mode</key><value>4</value></param>
<param><key>show_fail</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>show_stop</key><value>0</value></param>
<param><key>show_thre</key><value>0</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>cs_threshold</key><value>0.005</value></param>
</block>
<block>
<key>inets_cmd_editor</key>
<param><key>id</key><value>inets_cmd_editor_0</value></param>
<param><key>block_id</key><value>52</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>field_name</key><value>"num_transmission"</value></param>
<param><key>operation</key><value>1</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>""</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>""</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0_0</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>""</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0_0_0</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>""</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0_1</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>""</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0_2</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>""</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0_2_0</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>""</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_1</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>""</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_switch</key>
<param><key>id</key><value>inets_cmd_switch_0</value></param>
<param><key>block_id</key><value>47</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>1</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"node"+str(source_address)+"_bad_frame"</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>10</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"node"+str(source_address)+"_acked"</value></param>
<param><key>record_on</key><value>1</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>name_with_stamp</key><value>0</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_0_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>11</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"node"+str(source_address)+"_sent"</value></param>
<param><key>record_on</key><value>1</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>name_with_stamp</key><value>0</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_0_0_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>11</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"node"+str(source_address)+"_busy"</value></param>
<param><key>record_on</key><value>1</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>name_with_stamp</key><value>0</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_0_0_0_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>11</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"node"+str(source_address)+"_retransmission"</value></param>
<param><key>record_on</key><value>1</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>name_with_stamp</key><value>0</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_0_0_0_1</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>11</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"node"+str(source_address)+"_dropped"</value></param>
<param><key>record_on</key><value>1</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>name_with_stamp</key><value>0</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_0_0_1</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>11</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"node"+str(source_address)+"_gen"</value></param>
<param><key>record_on</key><value>1</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>name_with_stamp</key><value>0</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_0_1</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>4</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"node"+str(source_address)+"_node4_data"</value></param>
<param><key>record_on</key><value>1</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>name_with_stamp</key><value>0</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_0_1_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>4</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"node"+str(source_address)+"_node4_ack"</value></param>
<param><key>record_on</key><value>1</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>name_with_stamp</key><value>0</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_1</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>2</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"node"+str(source_address)+"_node2_data"</value></param>
<param><key>record_on</key><value>1</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>name_with_stamp</key><value>0</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_1_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>2</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"node"+str(source_address)+"_node2_ack"</value></param>
<param><key>record_on</key><value>1</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>name_with_stamp</key><value>0</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_3</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>3</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"node"+str(source_address)+"_node3_data"</value></param>
<param><key>record_on</key><value>1</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>name_with_stamp</key><value>0</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_3_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>3</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"node"+str(source_address)+"_node3_ack"</value></param>
<param><key>record_on</key><value>1</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>name_with_stamp</key><value>0</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_1</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>1</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"node"+str(source_address)+"_node1_data"</value></param>
<param><key>record_on</key><value>1</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>name_with_stamp</key><value>0</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_1_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>1</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"node"+str(source_address)+"_node1_ack"</value></param>
<param><key>record_on</key><value>1</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>name_with_stamp</key><value>0</value></param>
</block>
<block>
<key>inets_dummy_source</key>
<param><key>id</key><value>inets_dummy_source_0</value></param>
<param><key>block_id</key><value>23</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>packet_rate</key><value>1</value></param>
<param><key>payload_length</key><value>837</value></param>
<param><key>show</key><value>1</value></param>
<param><key>source_type</key><value>3</value></param>
</block>
<block>
<key>inets_frame_analysis</key>
<param><key>id</key><value>inets_frame_analysis_0</value></param>
<param><key>apply_self_address_check</key><value>1</value></param>
<param><key>block_id</key><value>7</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>my_address</key><value>source_address</value></param>
</block>
<block>
<key>inets_frame_check</key>
<param><key>id</key><value>inets_frame_check_0</value></param>
<param><key>block_id</key><value>9</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_bad_frame</key><value>0</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
</block>
<block>
<key>inets_frame_counter</key>
<param><key>id</key><value>inets_frame_counter_0</value></param>
<param><key>block_id</key><value>36</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>counts</key><value>14</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>set</key><value>0</value></param>
<param><key>unselect</key><value>0</value></param>
</block>
<block>
<key>inets_frame_lifetime</key>
<param><key>id</key><value>inets_frame_lifetime_0</value></param>
<param><key>block_id</key><value>202</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>enable_new_name</key><value>0</value></param>
<param><key>output_l</key><value>1</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>recorder_name</key><value>"node"+str(source_address)+"_roundtime_success"</value></param>
<param><key>record_on</key><value>1</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_timestamp</key><value>0</value></param>
</block>
<block>
<key>inets_frame_lifetime</key>
<param><key>id</key><value>inets_frame_lifetime_0_0</value></param>
<param><key>block_id</key><value>201</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>enable_new_name</key><value>0</value></param>
<param><key>output_l</key><value>1</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>recorder_name</key><value>"node"+str(source_address)+"_roundtime_fail"</value></param>
<param><key>record_on</key><value>1</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_timestamp</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_1_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_1_0_1</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_0</value></param>
<param><key>block_id</key><value>100</value></param>
<param><key>cs_threshold</key><value>0.001</value></param>
<param><key>cs_mode</key><value>0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>enable_new_name</key><value>0</value></param>
<param><key>file_name_extension</key><value>""</value></param>
<param><key>output_time_info</key><value>1</value></param>
<param><key>print_frame</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_1</value></param>
<param><key>block_id</key><value>999</value></param>
<param><key>cs_threshold</key><value>0.01</value></param>
<param><key>cs_mode</key><value>0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>enable_new_name</key><value>1</value></param>
<param><key>file_name_extension</key><value>""</value></param>
<param><key>output_time_info</key><value>1</value></param>
<param><key>print_frame</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_1_0</value></param>
<param><key>block_id</key><value>666</value></param>
<param><key>cs_threshold</key><value>0.01</value></param>
<param><key>cs_mode</key><value>0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>enable_new_name</key><value>1</value></param>
<param><key>file_name_extension</key><value>""</value></param>
<param><key>output_time_info</key><value>1</value></param>
<param><key>print_frame</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_frame_type_check</key>
<param><key>id</key><value>inets_frame_type_check_0</value></param>
<param><key>ack_frame</key><value>0</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>ampdu_subframe</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>amsdu_subframe</key><value>1</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>block_id</key><value>25</value></param>
<param><key>cts_frame</key><value>1</value></param>
<param><key>data_frame</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>other_frame</key><value>1</value></param>
<param><key>rts_frame</key><value>1</value></param>
</block>
<block>
<key>inets_frame_type_check</key>
<param><key>id</key><value>inets_frame_type_check_0_0</value></param>
<param><key>ack_frame</key><value>0</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>ampdu_subframe</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>amsdu_subframe</key><value>1</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>block_id</key><value>25</value></param>
<param><key>cts_frame</key><value>1</value></param>
<param><key>data_frame</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>other_frame</key><value>1</value></param>
<param><key>rts_frame</key><value>1</value></param>
</block>
<block>
<key>inets_frame_type_check</key>
<param><key>id</key><value>inets_frame_type_check_1</value></param>
<param><key>ack_frame</key><value>0</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>ampdu_subframe</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>amsdu_subframe</key><value>1</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>block_id</key><value>25</value></param>
<param><key>cts_frame</key><value>1</value></param>
<param><key>data_frame</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>other_frame</key><value>1</value></param>
<param><key>rts_frame</key><value>1</value></param>
</block>
<block>
<key>inets_framing</key>
<param><key>id</key><value>inets_framing_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>default_payload_length</key><value>300</value></param>
<param><key>destination_address</key><value>destination_address</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>frame_type</key><value>1</value></param>
<param><key>increase_index</key><value>1</value></param>
<param><key>frame_index</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_slot_time_beacon</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>node_list</key><value>[2, 3]</value></param>
<param><key>output_frame_pmt</key><value>1</value></param>
<param><key>reserved_field_I</key><value>318</value></param>
<param><key>reserved_field_II</key><value>524</value></param>
<param><key>reserved_field_ampdu</key><value>0</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>show_reset_index</key><value>1</value></param>
<param><key>show_reset_initial_index</key><value>1</value></param>
<param><key>slot_list_ms</key><value>[1000, 1000]</value></param>
<param><key>source_address</key><value>source_address</value></param>
<param><key>default_payload</key><value>0</value></param>
<param><key>internal_index</key><value>1</value></param>
</block>
<block>
<key>inets_framing</key>
<param><key>id</key><value>inets_framing_0_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>default_payload_length</key><value>300</value></param>
<param><key>destination_address</key><value>destination_address</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>frame_type</key><value>2</value></param>
<param><key>increase_index</key><value>1</value></param>
<param><key>frame_index</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_slot_time_beacon</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>node_list</key><value>[2, 3]</value></param>
<param><key>output_frame_pmt</key><value>1</value></param>
<param><key>reserved_field_I</key><value>318</value></param>
<param><key>reserved_field_II</key><value>524</value></param>
<param><key>reserved_field_ampdu</key><value>0</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>show_reset_index</key><value>1</value></param>
<param><key>show_reset_initial_index</key><value>1</value></param>
<param><key>slot_list_ms</key><value>[1000, 1000]</value></param>
<param><key>source_address</key><value>source_address</value></param>
<param><key>default_payload</key><value>0</value></param>
<param><key>internal_index</key><value>1</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_0_1</value></param>
<param><key>block_id</key><value>3</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>SIFS+slot_time * 2</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_0_1_0</value></param>
<param><key>block_id</key><value>3</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>0</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_0_2</value></param>
<param><key>block_id</key><value>5</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>Single_rxp_time_s * 1000</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>inets_number_recorder</key>
<param><key>id</key><value>inets_number_recorder_0</value></param>
<param><key>block_id</key><value>50</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>enable_new_name</key><value>0</value></param>
<param><key>recorder_name</key><value>"node"+str(source_address)+"_bof_busy"</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_timestamp</key><value>0</value></param>
</block>
<block>
<key>inets_number_recorder</key>
<param><key>id</key><value>inets_number_recorder_0_0</value></param>
<param><key>block_id</key><value>50</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>enable_new_name</key><value>0</value></param>
<param><key>recorder_name</key><value>"node"+str(source_address)+"_num_transmission"</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_timestamp</key><value>0</value></param>
</block>
<block>
<key>inets_number_recorder</key>
<param><key>id</key><value>inets_number_recorder_0_1</value></param>
<param><key>block_id</key><value>50</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>enable_new_name</key><value>0</value></param>
<param><key>recorder_name</key><value>"node"+str(source_address)+"_bof_time"</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_timestamp</key><value>0</value></param>
</block>
<block>
<key>inets_parameter_list</key>
<param><key>id</key><value>inets_parameter_list_0</value></param>
<param><key>block_id</key><value>49</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_n</key><value>0</value></param>
<param><key>list</key><value>[1, 0.738905609893065, 0.448168907033806, 0.271828182845905, 0.164872127070013, 0.100000000000000, 0.060653065971263, 0.036787944117144, 0.022313016014843, 0.013533528323661, 0.008208499862390, 0.004978706836786, 0.003019738342232, 0.001831563888873, 0.001110899653824, 0.000673794699909, 0.000408677143846, 0.000247875217667, 1, 0.738905609893065, 0.448168907033806, 0.271828182845905, 0.164872127070013, 0.100000000000000, 0.060653065971263, 0.036787944117144, 0.022313016014843, 0.013533528323661, 0.008208499862390, 0.004978706836786, 0.003019738342232, 0.001831563888873, 0.001110899653824, 0.000673794699909, 0.000408677143846, 0.000247875217667, 1, 0.738905609893065, 0.448168907033806, 0.271828182845905, 0.164872127070013, 0.100000000000000, 0.060653065971263, 0.036787944117144, 0.022313016014843, 0.013533528323661, 0.008208499862390, 0.004978706836786, 0.003019738342232, 0.001831563888873, 0.001110899653824, 0.000673794699909, 0.000408677143846, 0.000247875217667, 1, 0.738905609893065, 0.448168907033806, 0.271828182845905, 0.164872127070013, 0.100000000000000, 0.060653065971263, 0.036787944117144, 0.022313016014843, 0.013533528323661, 0.008208499862390, 0.004978706836786, 0.003019738342232, 0.001831563888873, 0.001110899653824, 0.000673794699909, 0.000408677143846, 0.000247875217667, 1, 0.738905609893065, 0.448168907033806, 0.271828182845905, 0.164872127070013, 0.100000000000000, 0.060653065971263, 0.036787944117144, 0.022313016014843, 0.013533528323661, 0.008208499862390, 0.004978706836786, 0.003019738342232, 0.001831563888873, 0.001110899653824, 0.000673794699909, 0.000408677143846, 0.000247875217667, 1, 0.738905609893065, 0.448168907033806, 0.271828182845905, 0.164872127070013, 0.100000000000000, 0.060653065971263, 0.036787944117144, 0.022313016014843, 0.013533528323661, 0.008208499862390, 0.004978706836786, 0.003019738342232, 0.001831563888873, 0.001110899653824, 0.000673794699909, 0.000408677143846, 0.000247875217667, 1, 0.738905609893065, 0.448168907033806, 0.271828182845905, 0.164872127070013, 0.100000000000000, 0.060653065971263, 0.036787944117144, 0.022313016014843, 0.013533528323661, 0.008208499862390, 0.004978706836786, 0.003019738342232, 0.001831563888873, 0.001110899653824, 0.000673794699909, 0.000408677143846, 0.000247875217667, 1, 0.738905609893065, 0.448168907033806, 0.271828182845905, 0.164872127070013, 0.100000000000000, 0.060653065971263, 0.036787944117144, 0.022313016014843, 0.013533528323661, 0.008208499862390, 0.004978706836786, 0.003019738342232, 0.001831563888873, 0.001110899653824, 0.000673794699909, 0.000408677143846, 0.000247875217667, 1, 0.738905609893065, 0.448168907033806, 0.271828182845905, 0.164872127070013, 0.100000000000000, 0.060653065971263, 0.036787944117144, 0.022313016014843, 0.013533528323661, 0.008208499862390, 0.004978706836786, 0.003019738342232, 0.001831563888873, 0.001110899653824, 0.000673794699909, 0.000408677143846, 0.000247875217667, 1, 0.738905609893065, 0.448168907033806, 0.271828182845905, 0.164872127070013, 0.100000000000000, 0.060653065971263, 0.036787944117144, 0.022313016014843, 0.013533528323661, 0.008208499862390, 0.004978706836786, 0.003019738342232, 0.001831563888873, 0.001110899653824, 0.000673794699909, 0.000408677143846, 0.000247875217667]</value></param>
</block>
<block>
<key>inets_random_filter</key>
<param><key>id</key><value>inets_random_filter_0</value></param>
<param><key>block_id</key><value>3</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>lose</key><value>1</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>threshold</key><value>0.95</value></param>
</block>
<block>
<key>inets_receiving</key>
<param><key>id</key><value>inets_receiving_0</value></param>
<param><key>block_id</key><value>21</value></param>
<param><key>center_frequency</key><value>rx_center_frequency</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>reset_rf</key><value>0</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>mu</key><value>mu</value></param>
<param><key>output_rss</key><value>0</value></param>
<param><key>output_rx_switch</key><value>0</value></param>
<param><key>output_snr</key><value>1</value></param>
<param><key>output_rx_frame</key><value>0</value></param>
<param><key>rx_gain</key><value>rx_gain</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold</key><value>30</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>matched_filter_coeff</key><value>rrc</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>usrp_device_address</key><value>usrp_device_address</value></param>
</block>
<block>
<key>inets_resend_check</key>
<param><key>id</key><value>inets_resend_check_0</value></param>
<param><key>block_id</key><value>24</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>max_resend</key><value>6</value></param>
</block>
<block>
<key>inets_run</key>
<param><key>id</key><value>inets_run_0_0</value></param>
<param><key>start_next_time_s</key><value>20</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
</block>
<block>
<key>inets_sending</key>
<param><key>id</key><value>inets_sending_0</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>center_frequency</key><value>tx_center_frequency</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>interframe_interval_s</key><value>0.005</value></param>
<param><key>file_name_extension_pending</key><value>"Tfr"</value></param>
<param><key>file_name_extension_t_control</key><value>"t1TXs"</value></param>
<param><key>name_with_timestamp</key><value>0</value></param>
<param><key>t_pretx_interval_s</key><value>0.0002</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>ack_frame</key><value>1</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>cts_frame</key><value>1</value></param>
<param><key>data_frame</key><value>0</value></param>
<param><key>rts_frame</key><value>1</value></param>
<param><key>rx_control</key><value>0</value></param>
<param><key>unknown_frame</key><value>1</value></param>
<param><key>tx_gain</key><value>10</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>usrp_device_address</key><value>usrp_device_address</value></param>
</block>
<block>
<key>inets_standard_timer</key>
<param><key>id</key><value>inets_standard_timer_0</value></param>
<param><key>block_id</key><value>51</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration</key><value>slot_time</value></param>
<param><key>disable_timer</key><value>0</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
</block>
<block>
<key>inets_timeout</key>
<param><key>id</key><value>inets_timeout_0</value></param>
<param><key>block_id</key><value>10</value></param>
<param><key>data_ack</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>llc_protocol</key><value>0</value></param>
<param><key>rts_cts</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>1000</value></param>
<param><key>timeout_duration_ms</key><value>timeout_duration_ms</value></param>
</block>
<block>
<key>inets_unbundle</key>
<param><key>id</key><value>inets_unbundle_0</value></param>
<param><key>block_id</key><value>16</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>command_name</key><value>"num_transmission"</value></param>
</block>
<connection><source_block_id>inets_address_check_0</source_block_id><sink_block_id>inets_frame_type_check_0</sink_block_id><source_key>address_check_pass_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_address_check_2</source_block_id><sink_block_id>inets_counter_0_1</sink_block_id><source_key>address_check_pass_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_address_check_2_0</source_block_id><sink_block_id>inets_counter_0_0_1</sink_block_id><source_key>address_check_pass_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_address_check_2_0_0</source_block_id><sink_block_id>inets_counter_0_0_1_0</sink_block_id><source_key>address_check_pass_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_address_check_2_1</source_block_id><sink_block_id>inets_counter_0_0_3</sink_block_id><source_key>address_check_pass_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_address_check_2_1_0</source_block_id><sink_block_id>inets_counter_0_0_3_0</sink_block_id><source_key>address_check_pass_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_address_check_2_2</source_block_id><sink_block_id>inets_counter_0_0_0_1</sink_block_id><source_key>address_check_pass_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_address_check_2_2_0</source_block_id><sink_block_id>inets_counter_0_0_0_1_0</sink_block_id><source_key>address_check_pass_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_address_check_2_3</source_block_id><sink_block_id>inets_counter_0_1_0</sink_block_id><source_key>address_check_pass_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_backoff_0</source_block_id><sink_block_id>inets_number_recorder_0_1</sink_block_id><source_key>bof_time_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_backoff_0</source_block_id><sink_block_id>inets_number_recorder_0</sink_block_id><source_key>busy_time_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_backoff_0</source_block_id><sink_block_id>inets_cmd_editor_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_backoff_1</source_block_id><sink_block_id>inets_cmd_switch_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>switch_on</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0</source_block_id><sink_block_id>inets_backoff_0</sink_block_id><source_key>cmd_fail_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0</source_block_id><sink_block_id>inets_counter_0_0_0_0_0</sink_block_id><source_key>cmd_fail_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0</source_block_id><sink_block_id>inets_frame_probe_1_0</sink_block_id><source_key>cmd_fail_out</source_key><sink_key>info_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0</source_block_id><sink_block_id>inets_receiving_0</sink_block_id><source_key>cmd_pass_out</source_key><sink_key>rx_switch_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0</source_block_id><sink_block_id>inets_backoff_0</sink_block_id><source_key>cs_threshold_out</source_key><sink_key>cs_threshold_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0</source_block_id><sink_block_id>inets_cmd_path_0_0_0_0</sink_block_id><source_key>cs_threshold_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_cmd_editor_0</source_block_id><sink_block_id>inets_resend_check_0</sink_block_id><source_key>cmd_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0</source_block_id><sink_block_id>inets_standard_timer_0</sink_block_id><source_key>cmd_out</source_key><sink_key>disable_timer_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0</source_block_id><sink_block_id>inets_cmd_path_0_0_2</sink_block_id><source_key>cmd_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0</source_block_id><sink_block_id>inets_counter_0_0_0</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_counter</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0</source_block_id><sink_block_id>inets_counter_0_0_0_0</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_counter</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0</source_block_id><sink_block_id>inets_counter_0_0_0_0_0</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_counter</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0</source_block_id><sink_block_id>inets_counter_0_0_0_0_0_0</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_counter</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0</source_block_id><sink_block_id>inets_counter_0_0_0_0_1</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_counter</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0_0</source_block_id><sink_block_id>inets_backoff_1</sink_block_id><source_key>cmd_out</source_key><sink_key>power_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0_0_0</source_block_id><sink_block_id>inets_backoff_1</sink_block_id><source_key>cmd_out</source_key><sink_key>cs_threshold_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0_1</source_block_id><sink_block_id>inets_frame_lifetime_0</sink_block_id><source_key>cmd_out</source_key><sink_key>change_file_name_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0_1</source_block_id><sink_block_id>inets_frame_lifetime_0_0</sink_block_id><source_key>cmd_out</source_key><sink_key>change_file_name_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0_1</source_block_id><sink_block_id>inets_number_recorder_0</sink_block_id><source_key>cmd_out</source_key><sink_key>change_file_name_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0_1</source_block_id><sink_block_id>inets_number_recorder_0_0</sink_block_id><source_key>cmd_out</source_key><sink_key>change_file_name_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0_1</source_block_id><sink_block_id>inets_number_recorder_0_1</sink_block_id><source_key>cmd_out</source_key><sink_key>change_file_name_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0_2</source_block_id><sink_block_id>inets_cmd_path_0_0_2_0</sink_block_id><source_key>cmd_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0_2</source_block_id><sink_block_id>inets_counter_0_0_0_1</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_counter</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0_2</source_block_id><sink_block_id>inets_counter_0_0_1</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_counter</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0_2</source_block_id><sink_block_id>inets_counter_0_0_3</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_counter</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0_2</source_block_id><sink_block_id>inets_counter_0_1</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_counter</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0_2_0</source_block_id><sink_block_id>inets_counter_0_0_0_1_0</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_counter</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0_2_0</source_block_id><sink_block_id>inets_counter_0_0_1_0</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_counter</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0_2_0</source_block_id><sink_block_id>inets_counter_0_0_3_0</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_counter</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_0_2_0</source_block_id><sink_block_id>inets_counter_0_1_0</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_counter</sink_key></connection>
<connection><source_block_id>inets_cmd_path_1</source_block_id><sink_block_id>inets_frame_type_check_1</sink_block_id><source_key>cmd_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_cmd_switch_0</source_block_id><sink_block_id>inets_random_filter_0</sink_block_id><source_key>cmd_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_dummy_source_0</source_block_id><sink_block_id>inets_framing_0</sink_block_id><source_key>output</source_key><sink_key>data_in</sink_key></connection>
<connection><source_block_id>inets_frame_analysis_0</source_block_id><sink_block_id>inets_frame_check_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_check_0</source_block_id><sink_block_id>inets_counter_0_0</sink_block_id><source_key>bad_frame_info_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_frame_check_0</source_block_id><sink_block_id>inets_address_check_0</sink_block_id><source_key>good_frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_check_0</source_block_id><sink_block_id>inets_cmd_path_1</sink_block_id><source_key>good_frame_info_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_frame_counter_0</source_block_id><sink_block_id>inets_cmd_path_0</sink_block_id><source_key>select_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_frame_counter_0</source_block_id><sink_block_id>inets_general_timer_0_2</sink_block_id><source_key>unselect_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_frame_counter_0</source_block_id><sink_block_id>inets_parameter_list_0</sink_block_id><source_key>unselect_out</source_key><sink_key>trigger_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_0</source_block_id><sink_block_id>inets_carrier_sensing_0</sink_block_id><source_key>frame_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_0</source_block_id><sink_block_id>inets_general_timer_0_1</sink_block_id><source_key>frame_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_0_1</source_block_id><sink_block_id>inets_backoff_0</sink_block_id><source_key>frame_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_0_1</source_block_id><sink_block_id>inets_frame_probe_1</sink_block_id><source_key>frame_out</source_key><sink_key>info_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0</source_block_id><sink_block_id>inets_timeout_0</sink_block_id><source_key>ack_frame_info_out</source_key><sink_key>ack_frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0</source_block_id><sink_block_id>inets_framing_0_0</sink_block_id><source_key>data_frame_info_out</source_key><sink_key>data_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0_0</source_block_id><sink_block_id>inets_backoff_1</sink_block_id><source_key>ack_frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0_0</source_block_id><sink_block_id>inets_counter_0_0_0</sink_block_id><source_key>ack_frame_info_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0_0</source_block_id><sink_block_id>inets_frame_lifetime_0</sink_block_id><source_key>ack_frame_info_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0_0</source_block_id><sink_block_id>inets_unbundle_0</sink_block_id><source_key>ack_frame_info_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0_0</source_block_id><sink_block_id>inets_frame_path_1_0_1</sink_block_id><source_key>data_frame_info_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_1</source_block_id><sink_block_id>inets_address_check_2_0_0</sink_block_id><source_key>ack_frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_1</source_block_id><sink_block_id>inets_address_check_2_1_0</sink_block_id><source_key>ack_frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_1</source_block_id><sink_block_id>inets_address_check_2_2_0</sink_block_id><source_key>ack_frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_1</source_block_id><sink_block_id>inets_address_check_2_3</sink_block_id><source_key>ack_frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_1</source_block_id><sink_block_id>inets_address_check_2</sink_block_id><source_key>data_frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_1</source_block_id><sink_block_id>inets_address_check_2_0</sink_block_id><source_key>data_frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_1</source_block_id><sink_block_id>inets_address_check_2_1</sink_block_id><source_key>data_frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_1</source_block_id><sink_block_id>inets_address_check_2_2</sink_block_id><source_key>data_frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_framing_0</source_block_id><sink_block_id>inets_counter_0_0_0_0_1</sink_block_id><source_key>frame_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_framing_0</source_block_id><sink_block_id>inets_frame_path_1_0</sink_block_id><source_key>frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_framing_0_0</source_block_id><sink_block_id>inets_general_timer_0_1_0</sink_block_id><source_key>frame_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_0_1</source_block_id><sink_block_id>inets_carrier_sensing_0</sink_block_id><source_key>expire_signal_out</source_key><sink_key>stop_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_0_1_0</source_block_id><sink_block_id>inets_sending_0</sink_block_id><source_key>expire_signal_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_general_timer_0_2</source_block_id><sink_block_id>inets_cmd_path_0_0</sink_block_id><source_key>expire_signal_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_0_2</source_block_id><sink_block_id>inets_counter_0_0_0_0_0_1</sink_block_id><source_key>expire_signal_out</source_key><sink_key>reset_counter</sink_key></connection>
<connection><source_block_id>inets_general_timer_0_2</source_block_id><sink_block_id>inets_frame_counter_0</sink_block_id><source_key>expire_signal_out</source_key><sink_key>counts_in</sink_key></connection>
<connection><source_block_id>inets_parameter_list_0</source_block_id><sink_block_id>inets_frame_counter_0</sink_block_id><source_key>n_parameter_out</source_key><sink_key>set_n_counts_in</sink_key></connection>
<connection><source_block_id>inets_parameter_list_0</source_block_id><sink_block_id>inets_cmd_path_0_0_1</sink_block_id><source_key>parameter_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_parameter_list_0</source_block_id><sink_block_id>inets_random_filter_0</sink_block_id><source_key>parameter_out</source_key><sink_key>set_threshold</sink_key></connection>
<connection><source_block_id>inets_random_filter_0</source_block_id><sink_block_id>inets_cmd_switch_0</sink_block_id><source_key>win_cmd_out</source_key><sink_key>switch_off</sink_key></connection>
<connection><source_block_id>inets_random_filter_0</source_block_id><sink_block_id>inets_dummy_source_0</sink_block_id><source_key>win_cmd_out</source_key><sink_key>trigger</sink_key></connection>
<connection><source_block_id>inets_receiving_0</source_block_id><sink_block_id>inets_frame_analysis_0</sink_block_id><source_key>rx_frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0</source_block_id><sink_block_id>inets_backoff_0</sink_block_id><source_key>rx_power_out</source_key><sink_key>power_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0</source_block_id><sink_block_id>inets_carrier_sensing_0</sink_block_id><source_key>rx_power_out</source_key><sink_key>power_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0</source_block_id><sink_block_id>inets_cmd_path_0_0_0</sink_block_id><source_key>rx_power_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0</source_block_id><sink_block_id>inets_sending_0</sink_block_id><source_key>rx_switch_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_resend_check_0</source_block_id><sink_block_id>inets_cmd_switch_0</sink_block_id><source_key>resend_check_fail_out</source_key><sink_key>switch_on</sink_key></connection>
<connection><source_block_id>inets_resend_check_0</source_block_id><sink_block_id>inets_counter_0_0_0_0_0_1</sink_block_id><source_key>resend_check_fail_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_resend_check_0</source_block_id><sink_block_id>inets_frame_lifetime_0_0</sink_block_id><source_key>resend_check_fail_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_resend_check_0</source_block_id><sink_block_id>inets_unbundle_0</sink_block_id><source_key>resend_check_fail_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_resend_check_0</source_block_id><sink_block_id>inets_counter_0_0_0_0_0_0</sink_block_id><source_key>resend_check_pass_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_resend_check_0</source_block_id><sink_block_id>inets_frame_path_1_0</sink_block_id><source_key>resend_check_pass_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_run_0_0</source_block_id><sink_block_id>inets_general_timer_0_2</sink_block_id><source_key>trigger_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_run_0_0</source_block_id><sink_block_id>inets_parameter_list_0</sink_block_id><source_key>trigger_out</source_key><sink_key>trigger_in</sink_key></connection>
<connection><source_block_id>inets_run_0_0</source_block_id><sink_block_id>inets_standard_timer_0</sink_block_id><source_key>trigger_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_sending_0</source_block_id><sink_block_id>inets_counter_0_0_0_0</sink_block_id><source_key>data_frame_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_sending_0</source_block_id><sink_block_id>inets_timeout_0</sink_block_id><source_key>data_frame_out</source_key><sink_key>data_frame_info_in</sink_key></connection>
<connection><source_block_id>inets_sending_0</source_block_id><sink_block_id>inets_receiving_0</sink_block_id><source_key>rx_control_out</source_key><sink_key>rx_switch_in</sink_key></connection>
<connection><source_block_id>inets_standard_timer_0</source_block_id><sink_block_id>inets_cmd_switch_0</sink_block_id><source_key>expire_cmd_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_timeout_0</source_block_id><sink_block_id>inets_frame_type_check_0_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_unbundle_0</source_block_id><sink_block_id>inets_number_recorder_0_0</sink_block_id><source_key>cmd_out</source_key><sink_key>cmd_in</sink_key></connection>
</flow_graph>
