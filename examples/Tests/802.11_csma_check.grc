<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>csma_80211_check</value></param>
<param><key>author</key><value>PWA</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>csma_80211_check</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SIFS</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Single_rxp_time_s</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cs_threshold</value></param>
<param><key>value</key><value>0.001</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_address</value></param>
<param><key>value</key><value>101</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>device_1</value></param>
<param><key>value</key><value>"addr=10.0.0.6"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>device_2</value></param>
<param><key>value</key><value>"addr=10.0.0.14"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>device_3</value></param>
<param><key>value</key><value>"addr=10.0.0.16"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>device_4</value></param>
<param><key>value</key><value>"addr=10.0.0.3"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>device_5</value></param>
<param><key>value</key><value>"addr=10.0.0.9"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>diff_preamble_128</value></param>
<param><key>value</key><value>[1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0,0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0,0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1,1, 1, 1, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 1, 0, 0][0:128]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mu</value></param>
<param><key>value</key><value>0.6</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_center_frequency</value></param>
<param><key>value</key><value>3.9e8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain_1</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain_2</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain_3</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain_4</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain_5</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>400000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>slot_time</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_address</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>system_time_granularity_us</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timeout_duration_ms</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_center_frequency</value></param>
<param><key>value</key><value>3.9e8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_gain_1</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_gain_2</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_gain_3</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_gain_4</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_gain_5</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_interval</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import gnuradio</value></param>
</block>
<block>
<key>inets_carrier_sensing</key>
<param><key>id</key><value>inets_carrier_sensing_0</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>rx_sensitivity_dB</key><value>5</value></param>
<param><key>nf_initial_n</key><value>100</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>cs_duration</key><value>50</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>cs_mode</key><value>2</value></param>
<param><key>show_fail</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>show_stop</key><value>1</value></param>
<param><key>show_thre</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>cs_threshold</key><value>cs_threshold</value></param>
</block>
<block>
<key>inets_carrier_sensing</key>
<param><key>id</key><value>inets_carrier_sensing_0_0</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>rx_sensitivity_dB</key><value>5</value></param>
<param><key>nf_initial_n</key><value>100</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>cs_duration</key><value>50</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>cs_mode</key><value>2</value></param>
<param><key>show_fail</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>show_stop</key><value>1</value></param>
<param><key>show_thre</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>cs_threshold</key><value>cs_threshold</value></param>
</block>
<block>
<key>inets_carrier_sensing</key>
<param><key>id</key><value>inets_carrier_sensing_0_1</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>rx_sensitivity_dB</key><value>5</value></param>
<param><key>nf_initial_n</key><value>100</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>cs_duration</key><value>50</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>cs_mode</key><value>2</value></param>
<param><key>show_fail</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>show_stop</key><value>1</value></param>
<param><key>show_thre</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>cs_threshold</key><value>cs_threshold</value></param>
</block>
<block>
<key>inets_carrier_sensing</key>
<param><key>id</key><value>inets_carrier_sensing_0_2</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>rx_sensitivity_dB</key><value>5</value></param>
<param><key>nf_initial_n</key><value>100</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>cs_duration</key><value>50</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>cs_mode</key><value>2</value></param>
<param><key>show_fail</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>show_stop</key><value>1</value></param>
<param><key>show_thre</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>cs_threshold</key><value>cs_threshold</value></param>
</block>
<block>
<key>inets_carrier_sensing</key>
<param><key>id</key><value>inets_carrier_sensing_0_3</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>rx_sensitivity_dB</key><value>5</value></param>
<param><key>nf_initial_n</key><value>100</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>cs_duration</key><value>50</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>cs_mode</key><value>2</value></param>
<param><key>show_fail</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>show_stop</key><value>1</value></param>
<param><key>show_thre</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>cs_threshold</key><value>cs_threshold</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>""</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>"device_1_rx"</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0_0</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>"device_2_rx"</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0_0_0</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>"device_3_rx"</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0_0_0_0</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>"3_cs_fail"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0_0_0_0_0</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>"3_cs_pass"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0_0_1</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>"device_4_rx"</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0_0_1_0</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>"2_cs_fail"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0_0_1_0_0</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>"2_cs_pass"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0_0_2</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>"device_5_rx"</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0_0_2_0</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>"1_cs_fail"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0_0_2_0_0</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>"1_cs_pass"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0_0_3</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>"4_cs_fail"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0_0_3_0</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>"4_cs_pass"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0_1</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>"5_cs_fail"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_0_1_0</value></param>
<param><key>block_id</key><value>44</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>"5_cs_pass"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_1</value></param>
<param><key>block_id</key><value>1</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>"2_start_cs"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_1_0</value></param>
<param><key>block_id</key><value>2</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>"3_start_cs"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_1_1</value></param>
<param><key>block_id</key><value>3</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>"4_start_cs"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_1_2</value></param>
<param><key>block_id</key><value>4</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>"5_start_cs"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_cmd_path</key>
<param><key>id</key><value>inets_cmd_path_0_1_3</value></param>
<param><key>block_id</key><value>5</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>display</key><value>"1_start_cs"</value></param>
<param><key>switch_s</key><value>1</value></param>
</block>
<block>
<key>inets_dummy_source</key>
<param><key>id</key><value>inets_dummy_source_0</value></param>
<param><key>block_id</key><value>23</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>packet_rate</key><value>1</value></param>
<param><key>payload_length</key><value>837</value></param>
<param><key>show</key><value>1</value></param>
<param><key>source_type</key><value>1</value></param>
</block>
<block>
<key>inets_frame_analysis</key>
<param><key>id</key><value>inets_frame_analysis_0</value></param>
<param><key>apply_self_address_check</key><value>0</value></param>
<param><key>block_id</key><value>7</value></param>
<param><key>default_framing_setting</key><value>customized</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>my_address</key><value>source_address</value></param>
</block>
<block>
<key>inets_frame_analysis</key>
<param><key>id</key><value>inets_frame_analysis_0_0</value></param>
<param><key>apply_self_address_check</key><value>0</value></param>
<param><key>block_id</key><value>7</value></param>
<param><key>default_framing_setting</key><value>customized</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>my_address</key><value>source_address</value></param>
</block>
<block>
<key>inets_frame_analysis</key>
<param><key>id</key><value>inets_frame_analysis_0_0_0</value></param>
<param><key>apply_self_address_check</key><value>0</value></param>
<param><key>block_id</key><value>7</value></param>
<param><key>default_framing_setting</key><value>customized</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>my_address</key><value>source_address</value></param>
</block>
<block>
<key>inets_frame_analysis</key>
<param><key>id</key><value>inets_frame_analysis_0_0_1</value></param>
<param><key>apply_self_address_check</key><value>0</value></param>
<param><key>block_id</key><value>7</value></param>
<param><key>default_framing_setting</key><value>customized</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>my_address</key><value>source_address</value></param>
</block>
<block>
<key>inets_frame_analysis</key>
<param><key>id</key><value>inets_frame_analysis_0_0_2</value></param>
<param><key>apply_self_address_check</key><value>0</value></param>
<param><key>block_id</key><value>7</value></param>
<param><key>default_framing_setting</key><value>customized</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>my_address</key><value>source_address</value></param>
</block>
<block>
<key>inets_frame_check</key>
<param><key>id</key><value>inets_frame_check_0</value></param>
<param><key>block_id</key><value>9</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_bad_frame</key><value>1</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
</block>
<block>
<key>inets_frame_check</key>
<param><key>id</key><value>inets_frame_check_0_0</value></param>
<param><key>block_id</key><value>9</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_bad_frame</key><value>1</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
</block>
<block>
<key>inets_frame_check</key>
<param><key>id</key><value>inets_frame_check_0_0_0</value></param>
<param><key>block_id</key><value>9</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_bad_frame</key><value>1</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
</block>
<block>
<key>inets_frame_check</key>
<param><key>id</key><value>inets_frame_check_0_0_1</value></param>
<param><key>block_id</key><value>9</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_bad_frame</key><value>1</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
</block>
<block>
<key>inets_frame_check</key>
<param><key>id</key><value>inets_frame_check_0_0_2</value></param>
<param><key>block_id</key><value>9</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_bad_frame</key><value>1</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_0</value></param>
<param><key>block_id</key><value>100</value></param>
<param><key>cs_threshold</key><value>0.001</value></param>
<param><key>cs_mode</key><value>1</value></param>
<param><key>develop_mode</key><value>2</value></param>
<param><key>enable_new_name</key><value>1</value></param>
<param><key>file_name_extension</key><value>""</value></param>
<param><key>output_time_info</key><value>1</value></param>
<param><key>print_frame</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_framing</key>
<param><key>id</key><value>inets_framing_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>default_payload_length</key><value>300</value></param>
<param><key>destination_address</key><value>destination_address</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>frame_type</key><value>1</value></param>
<param><key>increase_index</key><value>1</value></param>
<param><key>frame_index</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_slot_time_beacon</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>node_list</key><value>[2, 3]</value></param>
<param><key>output_frame_pmt</key><value>1</value></param>
<param><key>reserved_field_I</key><value>318</value></param>
<param><key>reserved_field_II</key><value>524</value></param>
<param><key>reserved_field_ampdu</key><value>0</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>show_reset_index</key><value>1</value></param>
<param><key>show_reset_initial_index</key><value>1</value></param>
<param><key>slot_list_ms</key><value>[1000, 1000]</value></param>
<param><key>source_address</key><value>source_address</value></param>
<param><key>default_payload</key><value>0</value></param>
<param><key>internal_index</key><value>1</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_0</value></param>
<param><key>block_id</key><value>5</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>tx_interval</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_0_0</value></param>
<param><key>block_id</key><value>5</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>tx_interval</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_0_0_0</value></param>
<param><key>block_id</key><value>5</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>tx_interval</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_0_0_0_0</value></param>
<param><key>block_id</key><value>5</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>tx_interval</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_0_1</value></param>
<param><key>block_id</key><value>5</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>tx_interval</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>inets_receiving</key>
<param><key>id</key><value>inets_receiving_0</value></param>
<param><key>block_id</key><value>21</value></param>
<param><key>center_frequency</key><value>rx_center_frequency</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>reset_rf</key><value>1</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>mu</key><value>mu</value></param>
<param><key>output_rss</key><value>0</value></param>
<param><key>output_rx_switch</key><value>1</value></param>
<param><key>output_snr</key><value>1</value></param>
<param><key>output_rx_frame</key><value>0</value></param>
<param><key>rx_gain</key><value>rx_gain_1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold</key><value>30</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>matched_filter_coeff</key><value>rrc</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>usrp_device_address</key><value>device_1</value></param>
</block>
<block>
<key>inets_receiving</key>
<param><key>id</key><value>inets_receiving_0_0</value></param>
<param><key>block_id</key><value>21</value></param>
<param><key>center_frequency</key><value>rx_center_frequency</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>reset_rf</key><value>1</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>mu</key><value>mu</value></param>
<param><key>output_rss</key><value>0</value></param>
<param><key>output_rx_switch</key><value>1</value></param>
<param><key>output_snr</key><value>1</value></param>
<param><key>output_rx_frame</key><value>0</value></param>
<param><key>rx_gain</key><value>rx_gain_5</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold</key><value>30</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>matched_filter_coeff</key><value>rrc</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>usrp_device_address</key><value>device_5</value></param>
</block>
<block>
<key>inets_receiving</key>
<param><key>id</key><value>inets_receiving_0_1</value></param>
<param><key>block_id</key><value>21</value></param>
<param><key>center_frequency</key><value>rx_center_frequency</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>reset_rf</key><value>1</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>mu</key><value>mu</value></param>
<param><key>output_rss</key><value>0</value></param>
<param><key>output_rx_switch</key><value>1</value></param>
<param><key>output_snr</key><value>1</value></param>
<param><key>output_rx_frame</key><value>0</value></param>
<param><key>rx_gain</key><value>rx_gain_4</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold</key><value>30</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>matched_filter_coeff</key><value>rrc</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>usrp_device_address</key><value>device_4</value></param>
</block>
<block>
<key>inets_receiving</key>
<param><key>id</key><value>inets_receiving_0_2</value></param>
<param><key>block_id</key><value>21</value></param>
<param><key>center_frequency</key><value>rx_center_frequency</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>reset_rf</key><value>1</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>mu</key><value>mu</value></param>
<param><key>output_rss</key><value>0</value></param>
<param><key>output_rx_switch</key><value>1</value></param>
<param><key>output_snr</key><value>1</value></param>
<param><key>output_rx_frame</key><value>0</value></param>
<param><key>rx_gain</key><value>rx_gain_3</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold</key><value>30</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>matched_filter_coeff</key><value>rrc</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>usrp_device_address</key><value>device_3</value></param>
</block>
<block>
<key>inets_receiving</key>
<param><key>id</key><value>inets_receiving_0_3</value></param>
<param><key>block_id</key><value>21</value></param>
<param><key>center_frequency</key><value>rx_center_frequency</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>reset_rf</key><value>1</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>mu</key><value>mu</value></param>
<param><key>output_rss</key><value>0</value></param>
<param><key>output_rx_switch</key><value>1</value></param>
<param><key>output_snr</key><value>1</value></param>
<param><key>output_rx_frame</key><value>0</value></param>
<param><key>rx_gain</key><value>rx_gain_2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold</key><value>30</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>matched_filter_coeff</key><value>rrc</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>usrp_device_address</key><value>device_2</value></param>
</block>
<block>
<key>inets_run</key>
<param><key>id</key><value>inets_run_0</value></param>
<param><key>start_next_time_s</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
</block>
<block>
<key>inets_sending</key>
<param><key>id</key><value>inets_sending_0</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>center_frequency</key><value>tx_center_frequency</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interframe_interval_s</key><value>0</value></param>
<param><key>file_name_extension_pending</key><value>"Tfr"</value></param>
<param><key>file_name_extension_t_control</key><value>"t1TXs"</value></param>
<param><key>name_with_timestamp</key><value>0</value></param>
<param><key>t_pretx_interval_s</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>ack_frame</key><value>1</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>cts_frame</key><value>1</value></param>
<param><key>data_frame</key><value>0</value></param>
<param><key>rts_frame</key><value>1</value></param>
<param><key>rx_control</key><value>1</value></param>
<param><key>unknown_frame</key><value>1</value></param>
<param><key>tx_gain</key><value>tx_gain_1</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>usrp_device_address</key><value>device_1</value></param>
</block>
<block>
<key>inets_sending</key>
<param><key>id</key><value>inets_sending_0_0</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>center_frequency</key><value>tx_center_frequency</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interframe_interval_s</key><value>0</value></param>
<param><key>file_name_extension_pending</key><value>"Tfr"</value></param>
<param><key>file_name_extension_t_control</key><value>"t1TXs"</value></param>
<param><key>name_with_timestamp</key><value>0</value></param>
<param><key>t_pretx_interval_s</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>ack_frame</key><value>1</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>cts_frame</key><value>1</value></param>
<param><key>data_frame</key><value>0</value></param>
<param><key>rts_frame</key><value>1</value></param>
<param><key>rx_control</key><value>1</value></param>
<param><key>unknown_frame</key><value>1</value></param>
<param><key>tx_gain</key><value>tx_gain_2</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>usrp_device_address</key><value>device_2</value></param>
</block>
<block>
<key>inets_sending</key>
<param><key>id</key><value>inets_sending_0_0_0</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>center_frequency</key><value>tx_center_frequency</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>interframe_interval_s</key><value>0</value></param>
<param><key>file_name_extension_pending</key><value>"Tfr"</value></param>
<param><key>file_name_extension_t_control</key><value>"t1TXs"</value></param>
<param><key>name_with_timestamp</key><value>0</value></param>
<param><key>t_pretx_interval_s</key><value>0.0002</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>ack_frame</key><value>1</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>cts_frame</key><value>1</value></param>
<param><key>data_frame</key><value>0</value></param>
<param><key>rts_frame</key><value>1</value></param>
<param><key>rx_control</key><value>1</value></param>
<param><key>unknown_frame</key><value>1</value></param>
<param><key>tx_gain</key><value>tx_gain_4</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>usrp_device_address</key><value>device_4</value></param>
</block>
<block>
<key>inets_sending</key>
<param><key>id</key><value>inets_sending_0_0_0_0</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>center_frequency</key><value>tx_center_frequency</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interframe_interval_s</key><value>0</value></param>
<param><key>file_name_extension_pending</key><value>"Tfr"</value></param>
<param><key>file_name_extension_t_control</key><value>"t1TXs"</value></param>
<param><key>name_with_timestamp</key><value>0</value></param>
<param><key>t_pretx_interval_s</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>ack_frame</key><value>1</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>cts_frame</key><value>1</value></param>
<param><key>data_frame</key><value>0</value></param>
<param><key>rts_frame</key><value>1</value></param>
<param><key>rx_control</key><value>1</value></param>
<param><key>unknown_frame</key><value>1</value></param>
<param><key>tx_gain</key><value>tx_gain_5</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>usrp_device_address</key><value>device_5</value></param>
</block>
<block>
<key>inets_sending</key>
<param><key>id</key><value>inets_sending_0_1</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>center_frequency</key><value>tx_center_frequency</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interframe_interval_s</key><value>0</value></param>
<param><key>file_name_extension_pending</key><value>"Tfr"</value></param>
<param><key>file_name_extension_t_control</key><value>"t1TXs"</value></param>
<param><key>name_with_timestamp</key><value>0</value></param>
<param><key>t_pretx_interval_s</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>ack_frame</key><value>1</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>cts_frame</key><value>1</value></param>
<param><key>data_frame</key><value>0</value></param>
<param><key>rts_frame</key><value>1</value></param>
<param><key>rx_control</key><value>1</value></param>
<param><key>unknown_frame</key><value>1</value></param>
<param><key>tx_gain</key><value>tx_gain_3</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>usrp_device_address</key><value>device_3</value></param>
</block>
<connection><source_block_id>inets_carrier_sensing_0</source_block_id><sink_block_id>inets_cmd_path_0_0_1</sink_block_id><source_key>cmd_fail_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0</source_block_id><sink_block_id>inets_cmd_path_0_0_1_0</sink_block_id><source_key>cmd_pass_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0_0</source_block_id><sink_block_id>inets_cmd_path_0_0_0_1_0</sink_block_id><source_key>cmd_fail_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0_0</source_block_id><sink_block_id>inets_cmd_path_0_0_0_1_0_0</sink_block_id><source_key>cmd_pass_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0_1</source_block_id><sink_block_id>inets_cmd_path_0_0_0_3</sink_block_id><source_key>cmd_fail_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0_1</source_block_id><sink_block_id>inets_cmd_path_0_0_0_3_0</sink_block_id><source_key>cmd_pass_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0_2</source_block_id><sink_block_id>inets_cmd_path_0_0_0_0_0</sink_block_id><source_key>cmd_fail_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0_2</source_block_id><sink_block_id>inets_cmd_path_0_0_0_0_0_0</sink_block_id><source_key>cmd_pass_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0_3</source_block_id><sink_block_id>inets_cmd_path_0_0_0_2_0</sink_block_id><source_key>cmd_fail_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0_3</source_block_id><sink_block_id>inets_cmd_path_0_0_0_2_0_0</sink_block_id><source_key>cmd_pass_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0</source_block_id><sink_block_id>inets_carrier_sensing_0</sink_block_id><source_key>cmd_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0</source_block_id><sink_block_id>inets_carrier_sensing_0_0</sink_block_id><source_key>cmd_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0</source_block_id><sink_block_id>inets_carrier_sensing_0_1</sink_block_id><source_key>cmd_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0</source_block_id><sink_block_id>inets_carrier_sensing_0_2</sink_block_id><source_key>cmd_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0</source_block_id><sink_block_id>inets_carrier_sensing_0_3</sink_block_id><source_key>cmd_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_1_0</source_block_id><sink_block_id>inets_sending_0_1</sink_block_id><source_key>cmd_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_1_1</source_block_id><sink_block_id>inets_sending_0_0_0</sink_block_id><source_key>cmd_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_1_2</source_block_id><sink_block_id>inets_sending_0_0_0_0</sink_block_id><source_key>cmd_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_1_3</source_block_id><sink_block_id>inets_cmd_path_0</sink_block_id><source_key>cmd_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_cmd_path_0_1_3</source_block_id><sink_block_id>inets_sending_0_0_0</sink_block_id><source_key>cmd_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_dummy_source_0</source_block_id><sink_block_id>inets_framing_0</sink_block_id><source_key>output</source_key><sink_key>data_in</sink_key></connection>
<connection><source_block_id>inets_frame_analysis_0</source_block_id><sink_block_id>inets_frame_check_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_analysis_0_0</source_block_id><sink_block_id>inets_frame_check_0_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_analysis_0_0_0</source_block_id><sink_block_id>inets_frame_check_0_0_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_analysis_0_0_1</source_block_id><sink_block_id>inets_frame_check_0_0_1</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_analysis_0_0_2</source_block_id><sink_block_id>inets_frame_check_0_0_2</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_check_0</source_block_id><sink_block_id>inets_cmd_path_0_0</sink_block_id><source_key>good_frame_info_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_frame_check_0_0</source_block_id><sink_block_id>inets_cmd_path_0_0_0</sink_block_id><source_key>good_frame_info_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_frame_check_0_0_0</source_block_id><sink_block_id>inets_cmd_path_0_0_0_0</sink_block_id><source_key>good_frame_info_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_frame_check_0_0_1</source_block_id><sink_block_id>inets_cmd_path_0_0_0_1</sink_block_id><source_key>good_frame_info_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_frame_check_0_0_2</source_block_id><sink_block_id>inets_cmd_path_0_0_0_2</sink_block_id><source_key>good_frame_info_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_framing_0</source_block_id><sink_block_id>inets_cmd_path_0_1_3</sink_block_id><source_key>frame_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_0</source_block_id><sink_block_id>inets_cmd_path_0_1</sink_block_id><source_key>expire_signal_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_0_0</source_block_id><sink_block_id>inets_cmd_path_0_1_0</sink_block_id><source_key>expire_signal_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_0_0_0</source_block_id><sink_block_id>inets_cmd_path_0_1_2</sink_block_id><source_key>expire_signal_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_0_0_0_0</source_block_id><sink_block_id>inets_cmd_path_0_1_3</sink_block_id><source_key>expire_signal_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_0_1</source_block_id><sink_block_id>inets_cmd_path_0_1_1</sink_block_id><source_key>expire_signal_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0</source_block_id><sink_block_id>inets_frame_analysis_0</sink_block_id><source_key>rx_frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0</source_block_id><sink_block_id>inets_carrier_sensing_0_3</sink_block_id><source_key>rx_power_out</source_key><sink_key>power_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0_0</source_block_id><sink_block_id>inets_frame_analysis_0_0_2</sink_block_id><source_key>rx_frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0_0</source_block_id><sink_block_id>inets_carrier_sensing_0</sink_block_id><source_key>rx_power_out</source_key><sink_key>power_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0_1</source_block_id><sink_block_id>inets_frame_analysis_0_0_1</sink_block_id><source_key>rx_frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0_1</source_block_id><sink_block_id>inets_carrier_sensing_0_1</sink_block_id><source_key>rx_power_out</source_key><sink_key>power_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0_2</source_block_id><sink_block_id>inets_frame_analysis_0_0_0</sink_block_id><source_key>rx_frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0_2</source_block_id><sink_block_id>inets_carrier_sensing_0_2</sink_block_id><source_key>rx_power_out</source_key><sink_key>power_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0_3</source_block_id><sink_block_id>inets_frame_analysis_0_0</sink_block_id><source_key>rx_frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0_3</source_block_id><sink_block_id>inets_carrier_sensing_0_0</sink_block_id><source_key>rx_power_out</source_key><sink_key>power_in</sink_key></connection>
<connection><source_block_id>inets_run_0</source_block_id><sink_block_id>inets_dummy_source_0</sink_block_id><source_key>trigger_out</source_key><sink_key>trigger</sink_key></connection>
<connection><source_block_id>inets_sending_0</source_block_id><sink_block_id>inets_general_timer_0</sink_block_id><source_key>data_frame_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_sending_0_0</source_block_id><sink_block_id>inets_general_timer_0_0</sink_block_id><source_key>data_frame_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_sending_0_0_0</source_block_id><sink_block_id>inets_general_timer_0_0_0</sink_block_id><source_key>data_frame_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_sending_0_0_0_0</source_block_id><sink_block_id>inets_general_timer_0_0_0_0</sink_block_id><source_key>data_frame_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_sending_0_1</source_block_id><sink_block_id>inets_general_timer_0_1</sink_block_id><source_key>data_frame_out</source_key><sink_key>active_in</sink_key></connection>
</flow_graph>
