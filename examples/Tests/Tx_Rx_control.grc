<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Tx_Rx_control</value></param>
<param><key>author</key><value>PWA</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Tx_Rx_control</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cs_threshold</value></param>
<param><key>value</key><value>0.005</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_address</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>diff_preamble_128</value></param>
<param><key>value</key><value>[1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0,0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0,0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1,1, 1, 1, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 1, 0, 0][0:128]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mu</value></param>
<param><key>value</key><value>range_mu</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_mu</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>BB Derotation Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_rx_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Rx Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_center_frequency</value></param>
<param><key>value</key><value>3.9e8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>range_rx_gain</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>400000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_address</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>system_time_granularity_us</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timeout_duration_ms</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_center_frequency</value></param>
<param><key>value</key><value>3.9e8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_device_address</value></param>
<param><key>value</key><value>"addr=10.0.0.6"</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import gnuradio</value></param>
</block>
<block>
<key>inets_dummy_source</key>
<param><key>id</key><value>inets_dummy_source_0</value></param>
<param><key>block_id</key><value>23</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>packet_rate</key><value>1</value></param>
<param><key>payload_length</key><value>100</value></param>
<param><key>show</key><value>1</value></param>
<param><key>source_type</key><value>1</value></param>
</block>
<block>
<key>send_frame</key>
<param><key>id</key><value>send_frame_0</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>samp_rate</key><value>4e6</value></param>
<param><key>sps</key><value>4</value></param>
<param><key>usrp_device_address</key><value>"addr=10.0.0.6"</value></param>
<param><key>block_id</key><value>4</value></param>
<param><key>center_frequency</key><value>400000000</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>file_name_extension</key><value>"t1TXs"</value></param>
<param><key>interframe_interval_s</key><value>0.005</value></param>
<param><key>preamble</key><value>[]</value></param>
<param><key>system_time_granularity_us</key><value>5</value></param>
<param><key>t_pretx_interval_s</key><value>0.05</value></param>
</block>
<connection><source_block_id>inets_dummy_source_0</source_block_id><sink_block_id>send_frame_0</sink_block_id><source_key>output</source_key><sink_key>in</sink_key></connection>
</flow_graph>
