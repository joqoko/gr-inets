<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>inets_dummy_source</key>
<param><key>id</key><value>inets_dummy_source_0</value></param>
<param><key>block_id</key><value>23</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>packet_rate</key><value>1</value></param>
<param><key>payload_length</key><value>100</value></param>
<param><key>source_type</key><value>2</value></param>
</block>
<block>
<key>inets_frame_comparer</key>
<param><key>id</key><value>inets_frame_comparer_0</value></param>
<param><key>block_id</key><value>27</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>output_equal_index_frame</key><value>0</value></param>
<param><key>output_equal_reI_frame</key><value>1</value></param>
<param><key>output_equal_reII_frame</key><value>1</value></param>
<param><key>output_higher_index_frame</key><value>0</value></param>
<param><key>output_higher_reI_frame</key><value>1</value></param>
<param><key>output_higher_reII_frame</key><value>1</value></param>
<param><key>output_lower_index_frame</key><value>0</value></param>
<param><key>output_lower_reI_frame</key><value>1</value></param>
<param><key>output_lower_reII_frame</key><value>1</value></param>
<param><key>single_input</key><value>0</value></param>
<param><key>what_to_compare</key><value>0</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_0</value></param>
<param><key>block_id</key><value>100</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>print_frame</key><value>0</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_0_0</value></param>
<param><key>block_id</key><value>102</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>print_frame</key><value>0</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_0_1</value></param>
<param><key>block_id</key><value>101</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>print_frame</key><value>0</value></param>
</block>
<block>
<key>inets_framing</key>
<param><key>id</key><value>inets_framing_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>destination_address</key><value>2</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>frame_type</key><value>1</value></param>
<param><key>increase_index</key><value>1</value></param>
<param><key>frame_index</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>output_frame_pmt</key><value>1</value></param>
<param><key>reserved_field_I</key><value>318</value></param>
<param><key>reserved_field_II</key><value>524</value></param>
<param><key>reserved_field_ampdu</key><value>0</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>source_address</key><value>1</value></param>
</block>
<block>
<key>inets_framing</key>
<param><key>id</key><value>inets_framing_0_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>destination_address</key><value>2</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>frame_type</key><value>1</value></param>
<param><key>increase_index</key><value>1</value></param>
<param><key>frame_index</key><value>3</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>output_frame_pmt</key><value>1</value></param>
<param><key>reserved_field_I</key><value>318</value></param>
<param><key>reserved_field_II</key><value>524</value></param>
<param><key>reserved_field_ampdu</key><value>0</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>source_address</key><value>1</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>inets_dummy_source_0</sink_block_id><source_key>strobe</source_key><sink_key>trigger</sink_key></connection>
<connection><source_block_id>inets_dummy_source_0</source_block_id><sink_block_id>inets_framing_0</sink_block_id><source_key>output</source_key><sink_key>data_in</sink_key></connection>
<connection><source_block_id>inets_dummy_source_0</source_block_id><sink_block_id>inets_framing_0_0</sink_block_id><source_key>output</source_key><sink_key>data_in</sink_key></connection>
<connection><source_block_id>inets_frame_comparer_0</source_block_id><sink_block_id>inets_frame_probe_0</sink_block_id><source_key>higher_indexed_frame</source_key><sink_key>info_in</sink_key></connection>
<connection><source_block_id>inets_frame_comparer_0</source_block_id><sink_block_id>inets_frame_probe_0_1</sink_block_id><source_key>lower_indexed_frame</source_key><sink_key>info_in</sink_key></connection>
<connection><source_block_id>inets_frame_comparer_0</source_block_id><sink_block_id>inets_frame_probe_0_0</sink_block_id><source_key>same_indexed_frame</source_key><sink_key>info_in</sink_key></connection>
<connection><source_block_id>inets_framing_0</source_block_id><sink_block_id>inets_frame_comparer_0</sink_block_id><source_key>frame_out</source_key><sink_key>frame_A_in</sink_key></connection>
<connection><source_block_id>inets_framing_0_0</source_block_id><sink_block_id>inets_frame_comparer_0</sink_block_id><source_key>frame_out</source_key><sink_key>frame_B_in</sink_key></connection>
</flow_graph>
