<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>C20</value></param>
<param><key>counter_id</key><value>11</value></param>
<param><key>develop_mode_list</key><value>11</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>inets_beginnen</key>
<param><key>id</key><value>inets_beginnen_0</value></param>
<param><key>block_id</key><value>0</value></param>
<param><key>develop_mode</key><value>1</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>inets_beginnen_0</sink_block_id><source_key>strobe</source_key><sink_key>trigger_in</sink_key></connection>
<connection><source_block_id>inets_beginnen_0</source_block_id><sink_block_id>C20</sink_block_id><source_key>out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_beginnen_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
</flow_graph>
