<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Test_idle</value></param>
<param><key>author</key><value>PWA</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Test_idle</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>develop_mode_list</value></param>
<param><key>value</key><value>[1, 2, 3]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>experiment_duration_s</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_buffer_size</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_num_retransmission</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>my_address</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>320000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe_random</key>
<param><key>id</key><value>blocks_message_strobe_random_0_0</value></param>
<param><key>dist</key><value>blocks.STROBE_POISSON</value></param>
<param><key>mean</key><value>2000</value></param>
<param><key>msg</key><value>pmt.from_bool(True)</value></param>
<param><key>std</key><value>2000</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>inets_idle</key>
<param><key>id</key><value>inets_idle_0</value></param>
<param><key>develop_mode_list</key><value>develop_mode_list</value></param>
<param><key>experiment_duration_s</key><value>experiment_duration_s</value></param>
<param><key>max_buffer_size</key><value>max_buffer_size</value></param>
<param><key>max_num_retransmission</key><value>max_num_retransmission</value></param>
<param><key>my_address</key><value>my_address</value></param>
</block>
<block>
<key>inets_message_tomb</key>
<param><key>id</key><value>inets_message_tomb_0</value></param>
</block>
<block>
<key>inets_null_message_source</key>
<param><key>id</key><value>inets_null_message_source_0</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_random_0_0</source_block_id><sink_block_id>inets_idle_0</sink_block_id><source_key>strobe</source_key><sink_key>reset_idle</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>inets_idle_0</sink_block_id><source_key>pdus</source_key><sink_key>data_in</sink_key></connection>
<connection><source_block_id>inets_idle_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>data_out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>inets_idle_0</source_block_id><sink_block_id>inets_message_tomb_0</sink_block_id><source_key>successful_transmission</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_null_message_source_0</source_block_id><sink_block_id>inets_idle_0</sink_block_id><source_key>null_message_out</source_key><sink_key>reset_idle</sink_key></connection>
</flow_graph>
