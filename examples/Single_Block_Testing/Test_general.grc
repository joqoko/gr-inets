<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Test_general</value></param>
<param><key>author</key><value>PWA</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Test_general</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cs_duration</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cs_threshold</value></param>
<param><key>value</key><value>0.005</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_address</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>develop_mode_list</value></param>
<param><key>value</key><value>[1, 2, 3]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>diff_preamble_128</value></param>
<param><key>value</key><value>[1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0,0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0,0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1,1, 1, 1, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 1, 0, 0][0:128]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_index</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_type</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>increase_index</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_destination_address</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_frame_index</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_frame_type</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_payload_length</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_reserved_field_I</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_reserved_field_II</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_source_address</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mu</value></param>
<param><key>value</key><value>range_mu</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_mu</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>BB Derotation Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_rx_gain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Rx Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>reserved_field_I</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>reserved_field_II</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>range_rx_gain</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_address</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>system_time_granularity_us</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>system_time_granularity_us_0</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timeout_duration_ms</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_device_address</value></param>
<param><key>value</key><value>"addr=10.0.0.6"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import gnuradio</value></param>
</block>
<block>
<key>inets_carrier_sensing</key>
<param><key>id</key><value>inets_carrier_sensing_0</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>cs_duration</key><value>cs_duration</value></param>
<param><key>cs_mode</key><value>1</value></param>
<param><key>cs_threshold</key><value>cs_threshold</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
</block>
<block>
<key>inets_frame_buffer</key>
<param><key>id</key><value>inets_frame_buffer_0</value></param>
<param><key>block_id</key><value>16</value></param>
<param><key>buffer_size</key><value>10</value></param>
<param><key>dequeue</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>enqueue</key><value>0</value></param>
<param><key>flush</key><value>1</value></param>
</block>
<block>
<key>inets_framing</key>
<param><key>id</key><value>inets_framing_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>destination_address</key><value>destination_address</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>frame_index</key><value>frame_index</value></param>
<param><key>frame_type</key><value>1</value></param>
<param><key>increase_index</key><value>1</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>0</value></param>
<param><key>len_payload_length</key><value>1</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>reserved_field_I</key><value>0</value></param>
<param><key>reserved_field_II</key><value>0</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>source_address</key><value>source_address</value></param>
</block>
<block>
<key>inets_receiving</key>
<param><key>id</key><value>inets_receiving_0</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>show_rss</key><value>1</value></param>
<param><key>show_snr</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>show_rx_constellation</key><value>1</value></param>
<param><key>show_correlation</key><value>1</value></param>
<param><key>show_f_offset</key><value>1</value></param>
<param><key>show_payload_const</key><value>1</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>matched_filter_coeff</key><value>rrc</value></param>
<param><key>mu</key><value>mu</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>rx_gain</key><value>rx_gain</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>threshold</key><value>cs_threshold</value></param>
<param><key>usrp_device_address</key><value>usrp_device_address</value></param>
</block>
<block>
<key>inets_sending</key>
<param><key>id</key><value>inets_sending_0</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>usrp_device_address</key><value>usrp_device_address</value></param>
</block>
<block>
<key>inets_timeout</key>
<param><key>id</key><value>inets_timeout_0</value></param>
<param><key>block_id</key><value>10</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>timeout_duration_ms</key><value>timeout_duration_ms</value></param>
</block>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>inets_framing_0</sink_block_id><source_key>pdus</source_key><sink_key>data_in</sink_key></connection>
<connection><source_block_id>inets_frame_buffer_0</source_block_id><sink_block_id>inets_sending_0</sink_block_id><source_key>dequeue_element</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_framing_0</source_block_id><sink_block_id>inets_frame_buffer_0</sink_block_id><source_key>frame_out</source_key><sink_key>enqueue</sink_key></connection>
</flow_graph>
