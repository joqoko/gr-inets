<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Test_idle_sendframe</value></param>
<param><key>author</key><value>PWA</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Test_idle_sendframe</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>another_ack_info</value></param>
<param><key>value</key><value>pmt.to_pmt({'frame_type': 2, 'frame_index': 1, 'destination_address': 1, 'source_address': 2, 'num_resend': 0, 'reserved_field_I': 1, 'reserved_field_II': 1, 'pay_load_length': 0})</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>another_data_info</value></param>
<param><key>value</key><value>pmt.to_pmt({'frame_type': 1, 'frame_index': 1, 'destination_address': 1, 'source_address': 2, 'num_resend': 3, 'reserved_field_I': 1, 'reserved_field_II': 1, 'pay_load_length': 200})</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>counter_id</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_address</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>develop_mode_list</value></param>
<param><key>value</key><value>[1, 2, 3, 20]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>experiment_duration_s</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_index</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_type</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>increase_index</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_destination_address</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_frame_index</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_frame_type</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_num_transmission</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_payload_length</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_reserved_field_I</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_reserved_field_II</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_source_address</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_buffer_size</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_num_retransmission</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>reserved_field_I</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>reserved_field_II</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>320000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>self_ack_info</value></param>
<param><key>value</key><value>pmt.to_pmt({'frame_type': 2, 'frame_index': 1, 'destination_address': 2, 'source_address': 1, 'num_resend': 0, 'reserved_field_I': 1, 'reserved_field_II': 1, 'pay_load_length': 0})</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>self_data_info</value></param>
<param><key>value</key><value>pmt.to_pmt({'frame_type': 1, 'frame_index': 1, 'destination_address': 2, 'source_address': 1, 'num_resend': 3, 'reserved_field_I': 1, 'reserved_field_II': 1, 'pay_load_length': 200})</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_address</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe_random</key>
<param><key>id</key><value>blocks_message_strobe_random_0_0_0</value></param>
<param><key>dist</key><value>blocks.STROBE_POISSON</value></param>
<param><key>mean</key><value>2000</value></param>
<param><key>msg</key><value>pmt.from_bool(True)</value></param>
<param><key>std</key><value>0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_message_strobe_random</key>
<param><key>id</key><value>frame_info_simulator</value></param>
<param><key>dist</key><value>blocks.STROBE_POISSON</value></param>
<param><key>mean</key><value>4000</value></param>
<param><key>msg</key><value>another_ack_info</value></param>
<param><key>std</key><value>2000</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import gnuradio</value></param>
</block>
<block>
<key>inets_idle</key>
<param><key>id</key><value>inets_idle_0</value></param>
<param><key>block_id</key><value>1</value></param>
<param><key>destination_address</key><value>destination_address</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>experiment_duration_s</key><value>experiment_duration_s</value></param>
<param><key>frame_index</key><value>frame_index</value></param>
<param><key>frame_type</key><value>frame_type</value></param>
<param><key>increase_index</key><value>increase_index</value></param>
<param><key>len_destination_address</key><value>len_destination_address</value></param>
<param><key>len_frame_index</key><value>len_frame_index</value></param>
<param><key>len_frame_type</key><value>len_frame_type</value></param>
<param><key>len_num_transmission</key><value>len_num_transmission</value></param>
<param><key>len_payload_length</key><value>len_payload_length</value></param>
<param><key>len_reserved_field_I</key><value>len_reserved_field_I</value></param>
<param><key>len_reserved_field_II</key><value>len_reserved_field_II</value></param>
<param><key>len_source_address</key><value>len_source_address</value></param>
<param><key>max_buffer_size</key><value>max_buffer_size</value></param>
<param><key>max_num_retransmission</key><value>max_num_retransmission</value></param>
<param><key>reserved_field_I</key><value>reserved_field_I</value></param>
<param><key>reserved_field_II</key><value>reserved_field_II</value></param>
<param><key>source_address</key><value>source_address</value></param>
</block>
<block>
<key>inets_message_tomb</key>
<param><key>id</key><value>inets_message_tomb_0</value></param>
</block>
<block>
<key>inets_null_message_source</key>
<param><key>id</key><value>inets_null_message_source_0</value></param>
</block>
<block>
<key>send_frame</key>
<param><key>id</key><value>send_frame_0</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>samp_rate</key><value>4e6</value></param>
<param><key>sps</key><value>4</value></param>
<param><key>destination_address</key><value>3</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>frame_index</key><value>2</value></param>
<param><key>frame_type</key><value>1</value></param>
<param><key>increase_index</key><value>1</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_payload_length</key><value>1</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>preamble</key><value>[]</value></param>
<param><key>reserved_field_I</key><value>5</value></param>
<param><key>reserved_field_II</key><value>6</value></param>
<param><key>source_address</key><value>4</value></param>
<param><key>system_time_granularity_us</key><value>5</value></param>
</block>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>inets_idle_0</sink_block_id><source_key>pdus</source_key><sink_key>data_in</sink_key></connection>
<connection><source_block_id>frame_info_simulator</source_block_id><sink_block_id>inets_idle_0</sink_block_id><source_key>strobe</source_key><sink_key>data_in</sink_key></connection>
<connection><source_block_id>inets_idle_0</source_block_id><sink_block_id>send_frame_0</sink_block_id><source_key>data_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_idle_0</source_block_id><sink_block_id>inets_message_tomb_0</sink_block_id><source_key>successful_transmission</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_null_message_source_0</source_block_id><sink_block_id>inets_idle_0</sink_block_id><source_key>null_message_out</source_key><sink_key>reset_idle</sink_key></connection>
<connection><source_block_id>send_frame_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>send_frame_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>tx_frame_info_out</source_key><sink_key>print</sink_key></connection>
</flow_graph>
