<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Test_general_timer</value></param>
<param><key>author</key><value>pwa</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Test_general_timer</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_address</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>inets_beacon_interpreter</key>
<param><key>id</key><value>inets_beacon_interpreter_0</value></param>
<param><key>block_id</key><value>29</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>len_address</key><value>1</value></param>
<param><key>len_slot_time_beacon</key><value>2</value></param>
<param><key>my_address</key><value>source_address</value></param>
</block>
<block>
<key>inets_dummy_source</key>
<param><key>id</key><value>inets_dummy_source_0</value></param>
<param><key>block_id</key><value>23</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>packet_rate</key><value>0.6</value></param>
<param><key>payload_length</key><value>10</value></param>
<param><key>source_type</key><value>2</value></param>
</block>
<block>
<key>inets_frame_analysis</key>
<param><key>id</key><value>inets_frame_analysis_0</value></param>
<param><key>apply_self_address_check</key><value>1</value></param>
<param><key>block_id</key><value>7</value></param>
<param><key>default_framing_setting</key><value>customized</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>my_address</key><value>2</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_0</value></param>
<param><key>block_id</key><value>100</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>print_frame</key><value>1</value></param>
</block>
<block>
<key>inets_framing</key>
<param><key>id</key><value>inets_framing_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>destination_address</key><value>2</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>frame_type</key><value>3</value></param>
<param><key>increase_index</key><value>1</value></param>
<param><key>frame_index</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_slot_time_beacon</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>node_list</key><value>[1,2,3,4, 5, 6]</value></param>
<param><key>output_frame_pmt</key><value>0</value></param>
<param><key>reserved_field_I</key><value>318</value></param>
<param><key>reserved_field_II</key><value>524</value></param>
<param><key>reserved_field_ampdu</key><value>0</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>slot_list_ms</key><value>[111, 222, 333, 444, 555, 666]</value></param>
<param><key>source_address</key><value>1</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_0</value></param>
<param><key>block_id</key><value>3</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>duration_ms</key><value>1000</value></param>
<param><key>kill_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>20</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>2</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>inets_dummy_source_0</sink_block_id><source_key>strobe</source_key><sink_key>trigger</sink_key></connection>
<connection><source_block_id>inets_beacon_interpreter_0</source_block_id><sink_block_id>inets_general_timer_0</sink_block_id><source_key>tx_sequence_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_dummy_source_0</source_block_id><sink_block_id>inets_framing_0</sink_block_id><source_key>output</source_key><sink_key>data_in</sink_key></connection>
<connection><source_block_id>inets_frame_analysis_0</source_block_id><sink_block_id>inets_beacon_interpreter_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>beacon_frame_in</sink_key></connection>
<connection><source_block_id>inets_framing_0</source_block_id><sink_block_id>inets_frame_analysis_0</sink_block_id><source_key>frame_pmt_out</source_key><sink_key>frame_in</sink_key></connection>
</flow_graph>
