<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Test_framing_cpp</value></param>
<param><key>author</key><value>PWA</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Test_framing_cpp</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cs_threshold</value></param>
<param><key>value</key><value>0.005</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_address</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>develop_mode_list</value></param>
<param><key>value</key><value>[1, 2, 3]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_index</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_type</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>increase_index</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_destination_address</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_frame_index</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_frame_type</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_payload_length</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_reserved_field_I</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_reserved_field_II</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_source_address</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>reserved_field_I</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>reserved_field_II</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_address</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>system_time_granularity_us</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>inets_IFS</key>
<param><key>id</key><value>inets_IFS_0</value></param>
<param><key>AIFS_ac</key><value>1</value></param>
<param><key>block_id</key><value>19</value></param>
<param><key>cs_threshold</key><value>cs_threshold</value></param>
<param><key>customized_IFS</key><value>0</value></param>
<param><key>default_cs_setting</key><value>default</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>interval_type</key><value>1</value></param>
<param><key>SIFS</key><value>10000</value></param>
<param><key>slot_time</key><value>8000</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
</block>
<block>
<key>inets_address_check</key>
<param><key>id</key><value>inets_address_check_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>my_address</key><value>destination_address</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
<param><key>show_not_pass</key><value>0</value></param>
</block>
<block>
<key>inets_frame_aggregation</key>
<param><key>id</key><value>inets_frame_aggregation_0</value></param>
<param><key>block_id</key><value>18</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>number_aggregation</key><value>4</value></param>
<param><key>output_frame_pmt</key><value>0</value></param>
</block>
<block>
<key>inets_frame_analysis</key>
<param><key>id</key><value>inets_frame_analysis_0</value></param>
<param><key>apply_self_address_check</key><value>1</value></param>
<param><key>block_id</key><value>7</value></param>
<param><key>default_framing_setting</key><value>customized</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>my_address</key><value>destination_address</value></param>
</block>
<block>
<key>inets_frame_check</key>
<param><key>id</key><value>inets_frame_check_0</value></param>
<param><key>block_id</key><value>9</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_bad_frame</key><value>1</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_0</value></param>
<param><key>block_id</key><value>100</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>print_frame</key><value>1</value></param>
</block>
<block>
<key>inets_framing</key>
<param><key>id</key><value>inets_framing_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>destination_address</key><value>destination_address</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>frame_index</key><value>frame_index</value></param>
<param><key>frame_type</key><value>8</value></param>
<param><key>increase_index</key><value>1</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>output_frame_pmt</key><value>0</value></param>
<param><key>reserved_field_I</key><value>318</value></param>
<param><key>reserved_field_II</key><value>524</value></param>
<param><key>reserved_field_ampdu</key><value>551</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>source_address</key><value>source_address</value></param>
</block>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>inets_framing_0</sink_block_id><source_key>pdus</source_key><sink_key>data_in</sink_key></connection>
<connection><source_block_id>inets_address_check_0</source_block_id><sink_block_id>inets_frame_probe_0</sink_block_id><source_key>address_check_pass_out</source_key><sink_key>info_in</sink_key></connection>
<connection><source_block_id>inets_frame_aggregation_0</source_block_id><sink_block_id>inets_frame_analysis_0</sink_block_id><source_key>aggregated_frame_pmt_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_analysis_0</source_block_id><sink_block_id>inets_frame_check_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_check_0</source_block_id><sink_block_id>inets_address_check_0</sink_block_id><source_key>good_frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_framing_0</source_block_id><sink_block_id>inets_frame_aggregation_0</sink_block_id><source_key>frame_out</source_key><sink_key>subframe_in</sink_key></connection>
</flow_graph>
