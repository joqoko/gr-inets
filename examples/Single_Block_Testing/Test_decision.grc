<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Test_decision</value></param>
<param><key>author</key><value>PWA</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Test_decision</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>develop_mode_list</value></param>
<param><key>value</key><value>[1, 3, 4, 14, 21, 22]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>320000</value></param>
</block>
<block>
<key>blocks_message_strobe_random</key>
<param><key>id</key><value>blocks_message_strobe_random_0</value></param>
<param><key>dist</key><value>blocks.STROBE_POISSON</value></param>
<param><key>mean</key><value>3000</value></param>
<param><key>msg</key><value>pmt.from_bool(True)</value></param>
<param><key>std</key><value>500</value></param>
</block>
<block>
<key>blocks_message_strobe_random</key>
<param><key>id</key><value>blocks_message_strobe_random_0_0</value></param>
<param><key>dist</key><value>blocks.STROBE_POISSON</value></param>
<param><key>mean</key><value>2000</value></param>
<param><key>msg</key><value>pmt.from_bool(False)</value></param>
<param><key>std</key><value>500</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0</value></param>
<param><key>counter_id</key><value>21</value></param>
<param><key>develop_mode_list</key><value>develop_mode_list</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0</value></param>
<param><key>counter_id</key><value>22</value></param>
<param><key>develop_mode_list</key><value>develop_mode_list</value></param>
</block>
<block>
<key>inets_decision_cpp</key>
<param><key>id</key><value>inets_decision_cpp_0</value></param>
<param><key>decision_index</key><value>14</value></param>
<param><key>develop_mode_list</key><value>develop_mode_list</value></param>
</block>
<block>
<key>inets_null_message_source</key>
<param><key>id</key><value>inets_null_message_source_0</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_random_0</source_block_id><sink_block_id>inets_decision_cpp_0</sink_block_id><source_key>strobe</source_key><sink_key>spark_in</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_random_0_0</source_block_id><sink_block_id>inets_decision_cpp_0</sink_block_id><source_key>strobe</source_key><sink_key>spark_in</sink_key></connection>
<connection><source_block_id>inets_decision_cpp_0</source_block_id><sink_block_id>inets_counter_0_0</sink_block_id><source_key>spark_out_f</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_decision_cpp_0</source_block_id><sink_block_id>inets_counter_0</sink_block_id><source_key>spark_out_t</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_null_message_source_0</source_block_id><sink_block_id>inets_decision_cpp_0</sink_block_id><source_key>null_message_out</source_key><sink_key>spark_in</sink_key></connection>
</flow_graph>
