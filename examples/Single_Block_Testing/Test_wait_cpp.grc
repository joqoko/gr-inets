<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>develop_mode</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>develop_mode_list</value></param>
<param><key>value</key><value>[1,2,3,4,5,6]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>320000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>system_time_granularity_us</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe_random</key>
<param><key>id</key><value>blocks_message_strobe_random_0</value></param>
<param><key>dist</key><value>blocks.STROBE_POISSON</value></param>
<param><key>mean</key><value>500</value></param>
<param><key>msg</key><value>pmt.cons(pmt.from_bool(True), pmt.from_float(200))</value></param>
<param><key>std</key><value>50</value></param>
</block>
<block>
<key>inets_wait_cpp</key>
<param><key>id</key><value>inets_wait_cpp_0</value></param>
<param><key>develop_mode_list</key><value>develop_mode_list</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_random_0</source_block_id><sink_block_id>inets_wait_cpp_0</sink_block_id><source_key>strobe</source_key><sink_key>wait_time_in</sink_key></connection>
<connection><source_block_id>inets_wait_cpp_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>spark_out</source_key><sink_key>print</sink_key></connection>
</flow_graph>
