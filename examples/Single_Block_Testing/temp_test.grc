<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>temp</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>temp</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_0</value></param>
<param><key>block_id</key><value>100</value></param>
<param><key>cs_threshold</key><value>0.01</value></param>
<param><key>cs_mode</key><value>0</value></param>
<param><key>develop_mode</key><value>2</value></param>
<param><key>file_name_extension</key><value>""</value></param>
<param><key>output_time_info</key><value>1</value></param>
<param><key>print_frame</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_run</key>
<param><key>id</key><value>inets_run_0</value></param>
<param><key>start_next_time_s</key><value>5</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
</block>
<connection><source_block_id>inets_run_0</source_block_id><sink_block_id>inets_frame_probe_0</sink_block_id><source_key>trigger_out</source_key><sink_key>info_in</sink_key></connection>
</flow_graph>
