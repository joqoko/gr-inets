<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>temp</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>temp</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>inets_run</key>
<param><key>id</key><value>inets_run_0</value></param>
<param><key>start_next_time_s</key><value>5</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
</block>
<block>
<key>send_frame</key>
<param><key>id</key><value>send_frame_0</value></param>
<param><key>constellation</key><value>1</value></param>
<param><key>samp_rate</key><value>4e6</value></param>
<param><key>sps</key><value>4</value></param>
<param><key>usrp_device_address</key><value>"addr=10.0.0.6"</value></param>
<param><key>block_id</key><value>4</value></param>
<param><key>center_frequency</key><value>400000000</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>file_name_extension_t_control</key><value>"t1TXs"</value></param>
<param><key>file_name_extension_pending</key><value>"t1Fr"</value></param>
<param><key>interframe_interval_s</key><value>0.005</value></param>
<param><key>name_with_timestamp</key><value>1</value></param>
<param><key>preamble</key><value>[]</value></param>
<param><key>record_on</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>5</value></param>
<param><key>t_pretx_interval_s</key><value>0.05</value></param>
</block>
<connection><source_block_id>inets_run_0</source_block_id><sink_block_id>send_frame_0</sink_block_id><source_key>trigger_out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
