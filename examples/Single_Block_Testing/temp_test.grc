<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>temp</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>temp</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CCA2_ms</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>PU_time_ms</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch_pool_size</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch_switch_ms</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cs_threshold</value></param>
<param><key>value</key><value>0.005</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_address</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>diff_preamble_128</value></param>
<param><key>value</key><value>[1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0,0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0,0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1,1, 1, 1, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 1, 0, 0][0:128]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_length</value></param>
<param><key>value</key><value>837</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>inter_fr_ms</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mu</value></param>
<param><key>value</key><value>range_mu</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_mu</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>BB Derotation Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_rx_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Rx Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_center_frequency</value></param>
<param><key>value</key><value>4e8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>range_rx_gain</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_mode_ms</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>400000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_address</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>system_time_granularity_us</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_center_frequency</value></param>
<param><key>value</key><value>4e8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_mode_ms</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_device_address</value></param>
<param><key>value</key><value>"addr=10.0.0.6"</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>constellation</value></param>
<param><key>label</key><value>Constellation</value></param>
<param><key>value</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import gnuradio</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_0</value></param>
<param><key>block_id</key><value>3</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>100</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>inets_rand_generator</key>
<param><key>id</key><value>inets_rand_generator_0</value></param>
<param><key>block_id</key><value>25</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>distribution</key><value>0</value></param>
<param><key>max</key><value>1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>mode</key><value>0</value></param>
</block>
<block>
<key>inets_run</key>
<param><key>id</key><value>inets_run_0</value></param>
<param><key>start_next_time_s</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
</block>
<connection><source_block_id>inets_general_timer_0</source_block_id><sink_block_id>inets_rand_generator_0</sink_block_id><source_key>expire_signal_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_rand_generator_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>cmd_out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>inets_rand_generator_0</source_block_id><sink_block_id>inets_general_timer_0</sink_block_id><source_key>cmd_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_run_0</source_block_id><sink_block_id>inets_rand_generator_0</sink_block_id><source_key>trigger_out</source_key><sink_key>cmd_in</sink_key></connection>
</flow_graph>
