<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>temp</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>temp</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CCA2_ms</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>PU_time_ms</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch_pool_size</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch_switch_ms</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cs_threshold</value></param>
<param><key>value</key><value>0.005</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_address</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>diff_preamble_128</value></param>
<param><key>value</key><value>[1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0,0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0,0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1,1, 1, 1, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 1, 0, 0][0:128]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_length</value></param>
<param><key>value</key><value>837</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>inter_fr_ms</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mu</value></param>
<param><key>value</key><value>range_mu</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_mu</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>BB Derotation Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_rx_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Rx Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_center_frequency</value></param>
<param><key>value</key><value>4e8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>range_rx_gain</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_mode_ms</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>400000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_address</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>system_time_granularity_us</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_center_frequency</value></param>
<param><key>value</key><value>4e8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_mode_ms</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_device_address</value></param>
<param><key>value</key><value>"addr=10.0.0.6"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>constellation</value></param>
<param><key>label</key><value>Constellation</value></param>
<param><key>value</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import gnuradio</value></param>
</block>
<block>
<key>inets_cogmac_timing</key>
<param><key>id</key><value>inets_cogmac_timing_0</value></param>
<param><key>block_id</key><value>37</value></param>
<param><key>CCA2_ms</key><value>CCA2_ms</value></param>
<param><key>ch_pool_size</key><value>ch_pool_size</value></param>
<param><key>ch_switch_ms</key><value>ch_switch_ms</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>frame_length</key><value>frame_length</value></param>
<param><key>inter_fr_ms</key><value>inter_fr_ms</value></param>
<param><key>len_mac_hdr</key><value>15</value></param>
<param><key>len_phy_overhead</key><value>148</value></param>
<param><key>PU_time_ms</key><value>PU_time_ms</value></param>
<param><key>padding</key><value>64</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>rx_mode_ms</key><value>rx_mode_ms</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>tx_mode_ms</key><value>tx_mode_ms</value></param>
<param><key>bps</key><value>constellation.bits_per_symbol() * (samp_rate / sps)</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_0</value></param>
<param><key>block_id</key><value>100</value></param>
<param><key>cs_threshold</key><value>0.01</value></param>
<param><key>cs_mode</key><value>0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>file_name_extension</key><value>""</value></param>
<param><key>output_time_info</key><value>1</value></param>
<param><key>print_frame</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_run</key>
<param><key>id</key><value>inets_run_0</value></param>
<param><key>start_next_time_s</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
</block>
<block>
<key>inets_unbundle</key>
<param><key>id</key><value>inets_unbundle_0</value></param>
<param><key>block_id</key><value>16</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>command_name</key><value>CCA1_ms</value></param>
</block>
<connection><source_block_id>inets_cogmac_timing_0</source_block_id><sink_block_id>inets_unbundle_0</sink_block_id><source_key>cogmac_config_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_run_0</source_block_id><sink_block_id>inets_cogmac_timing_0</sink_block_id><source_key>trigger_out</source_key><sink_key>trigger_in</sink_key></connection>
<connection><source_block_id>inets_unbundle_0</source_block_id><sink_block_id>inets_frame_probe_0</sink_block_id><source_key>cmd_out</source_key><sink_key>info_in</sink_key></connection>
</flow_graph>
