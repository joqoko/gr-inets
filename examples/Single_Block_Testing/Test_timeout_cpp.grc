<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Test_timeout_cpp</value></param>
<param><key>author</key><value>PWA</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Test_timeout_cpp</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>develop_mode_list</value></param>
<param><key>value</key><value>[1, 3, 4, 16]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>320000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>system_time_granularity_us</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timeout_duration_ms</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe_random</key>
<param><key>id</key><value>blocks_message_strobe_random_0</value></param>
<param><key>dist</key><value>blocks.STROBE_POISSON</value></param>
<param><key>mean</key><value>5000</value></param>
<param><key>msg</key><value>pmt.make_dict()</value></param>
<param><key>std</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe_random</key>
<param><key>id</key><value>blocks_message_strobe_random_0_0</value></param>
<param><key>dist</key><value>blocks.STROBE_POISSON</value></param>
<param><key>mean</key><value>2000</value></param>
<param><key>msg</key><value>pmt.make_dict()</value></param>
<param><key>std</key><value>1000</value></param>
</block>
<block>
<key>inets_decision_cpp</key>
<param><key>id</key><value>inets_decision_cpp_0</value></param>
<param><key>decision_index</key><value>14</value></param>
<param><key>develop_mode_list</key><value>develop_mode_list</value></param>
</block>
<block>
<key>inets_message_tomb</key>
<param><key>id</key><value>inets_message_tomb_0</value></param>
</block>
<block>
<key>inets_timeout_cpp</key>
<param><key>id</key><value>inets_timeout_cpp_0</value></param>
<param><key>develop_mode_list</key><value>develop_mode_list</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>timeout_duration_ms</key><value>timeout_duration_ms</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_random_0</source_block_id><sink_block_id>inets_timeout_cpp_0</sink_block_id><source_key>strobe</source_key><sink_key>tx_frame_info_in</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_random_0_0</source_block_id><sink_block_id>inets_timeout_cpp_0</sink_block_id><source_key>strobe</source_key><sink_key>ack_info_in</sink_key></connection>
<connection><source_block_id>inets_decision_cpp_0</source_block_id><sink_block_id>inets_message_tomb_0</sink_block_id><source_key>spark_out_f</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_decision_cpp_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>spark_out_t</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>inets_timeout_cpp_0</source_block_id><sink_block_id>inets_decision_cpp_0</sink_block_id><source_key>spark_out</source_key><sink_key>spark_in</sink_key></connection>
<connection><source_block_id>inets_timeout_cpp_0</source_block_id><sink_block_id>inets_message_tomb_0</sink_block_id><source_key>spark_out</source_key><sink_key>message_in</sink_key></connection>
</flow_graph>
