<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>develop_mode_list</value></param>
<param><key>value</key><value>[1, 3, 4, 15]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>320000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe_random</key>
<param><key>id</key><value>blocks_message_strobe_random_0</value></param>
<param><key>dist</key><value>blocks.STROBE_POISSON</value></param>
<param><key>mean</key><value>2000</value></param>
<param><key>msg</key><value>pmt.from_bool(True)</value></param>
</block>
<block>
<key>inets_exponential_backoff_cpp</key>
<param><key>id</key><value>inets_exponential_backoff_cpp_0</value></param>
<param><key>backoff_time_unit</key><value>20</value></param>
<param><key>develop_mode_list</key><value>develop_mode_list</value></param>
<param><key>max_n_backoff</key><value>6</value></param>
<param><key>min_backoff</key><value>20</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_random_0</source_block_id><sink_block_id>inets_exponential_backoff_cpp_0</sink_block_id><source_key>strobe</source_key><sink_key>spark_in</sink_key></connection>
<connection><source_block_id>inets_exponential_backoff_cpp_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>spark_out</source_key><sink_key>print</sink_key></connection>
</flow_graph>
