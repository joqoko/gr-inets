<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Test_tx_buff</value></param>
<param><key>author</key><value>PWA</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Test Tx buffer function</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>develop_mode_list</value></param>
<param><key>value</key><value>[1,2,3,4,5,6]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_buffer_size</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_strobe_random</key>
<param><key>id</key><value>blocks_message_strobe_random_0</value></param>
<param><key>dist</key><value>blocks.STROBE_POISSON</value></param>
<param><key>mean</key><value>2500</value></param>
<param><key>msg</key><value>pmt.from_bool(True)</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>inets_message_tomb</key>
<param><key>id</key><value>inets_message_tomb_0</value></param>
</block>
<block>
<key>inets_tx_buffer</key>
<param><key>id</key><value>inets_tx_buffer_0</value></param>
<param><key>develop_mode_list</key><value>develop_mode_list</value></param>
<param><key>max_buffer_size</key><value>max_buffer_size</value></param>
<param><key>policy</key><value>1</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_random_0</source_block_id><sink_block_id>inets_tx_buffer_0</sink_block_id><source_key>strobe</source_key><sink_key>spark_in</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>inets_tx_buffer_0</sink_block_id><source_key>pdus</source_key><sink_key>payload_in</sink_key></connection>
<connection><source_block_id>inets_tx_buffer_0</source_block_id><sink_block_id>inets_message_tomb_0</sink_block_id><source_key>payload_out</source_key><sink_key>message_in</sink_key></connection>
</flow_graph>
