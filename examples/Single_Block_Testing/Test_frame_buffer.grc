<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe_random</key>
<param><key>id</key><value>blocks_message_strobe_random_0</value></param>
<param><key>dist</key><value>blocks.STROBE_POISSON</value></param>
<param><key>mean</key><value>1000</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>inets_frame_buffer</key>
<param><key>id</key><value>inets_frame_buffer_0</value></param>
<param><key>block_id</key><value>16</value></param>
<param><key>buffer_size</key><value>10</value></param>
<param><key>dequeue</key><value>1</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>enqueue</key><value>0</value></param>
<param><key>flush</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_random_0</source_block_id><sink_block_id>inets_frame_buffer_0</sink_block_id><source_key>strobe</source_key><sink_key>flush</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>inets_frame_buffer_0</sink_block_id><source_key>pdus</source_key><sink_key>enqueue</sink_key></connection>
<connection><source_block_id>inets_frame_buffer_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>dequeue_element</source_key><sink_key>print_pdu</sink_key></connection>
</flow_graph>
