<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>apply_address_check</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>backoff_time_unit_ms</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>counter_id</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cs_duration</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cs_threshold</value></param>
<param><key>value</key><value>0.005</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_address</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_index</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_type</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>increase_index</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_destination_address</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_frame_index</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_frame_type</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_num_transmission</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_payload_length</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_reserved_field_I</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_reserved_field_II</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_source_address</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>min_backoff_ms</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>reserved_field_I</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>reserved_field_II</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_address</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>system_time_granularity_us</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timeout_duration_ms</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_device_address</value></param>
<param><key>value</key><value>"addr=10.0.0.6"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(1024)</value></param>
</block>
<block>
<key>inets_frame_type_check</key>
<param><key>id</key><value>inets_frame_type_check_0</value></param>
<param><key>ack_frame</key><value>0</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>cts_frame</key><value>0</value></param>
<param><key>data_frame</key><value>0</value></param>
<param><key>rts_frame</key><value>1</value></param>
</block>
<block>
<key>inets_idle</key>
<param><key>id</key><value>inets_idle_0</value></param>
<param><key>block_id</key><value>1</value></param>
<param><key>destination_address</key><value>destination_address</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>experiment_duration_s</key><value>1000</value></param>
<param><key>frame_index</key><value>frame_index</value></param>
<param><key>frame_type</key><value>frame_type</value></param>
<param><key>increase_index</key><value>increase_index</value></param>
<param><key>len_destination_address</key><value>len_destination_address</value></param>
<param><key>len_frame_index</key><value>len_frame_index</value></param>
<param><key>len_frame_type</key><value>len_frame_type</value></param>
<param><key>len_num_transmission</key><value>len_num_transmission</value></param>
<param><key>len_payload_length</key><value>len_payload_length</value></param>
<param><key>len_reserved_field_I</key><value>len_reserved_field_I</value></param>
<param><key>len_reserved_field_II</key><value>len_reserved_field_II</value></param>
<param><key>len_source_address</key><value>len_source_address</value></param>
<param><key>max_buffer_size</key><value>10</value></param>
<param><key>max_num_retransmission</key><value>6</value></param>
<param><key>reserved_field_I</key><value>reserved_field_I</value></param>
<param><key>reserved_field_II</key><value>reserved_field_II</value></param>
<param><key>source_address</key><value>source_address</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>parameter_0</value></param>
<param><key>value</key><value>1</value></param>
</block>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>inets_idle_0</sink_block_id><source_key>pdus</source_key><sink_key>data_in</sink_key></connection>
<connection><source_block_id>inets_idle_0</source_block_id><sink_block_id>inets_frame_type_check_0</sink_block_id><source_key>data_out</source_key><sink_key>frame_info_in</sink_key></connection>
</flow_graph>
