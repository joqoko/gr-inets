<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>CogMAC_III</value></param>
<param><key>author</key><value>PWA</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>CogMAC_III</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CCA2_ms</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_Mul_Fr</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>PU_time_ms</value></param>
<param><key>value</key><value>500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_frequency</value></param>
<param><key>value</key><value>460000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch_pool_size</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch_switch_ms</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cs_threshold</value></param>
<param><key>value</key><value>0.005</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_address</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>diff_preamble_128</value></param>
<param><key>value</key><value>[1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0,0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0,0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1,1, 1, 1, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 1, 0, 0][0:128]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_length</value></param>
<param><key>value</key><value>837</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>inter_fr_ms</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mu</value></param>
<param><key>value</key><value>range_mu</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>padding</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_mu</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>BB Derotation Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_rx_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Rx Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>range_rx_gain</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_mode_ms</value></param>
<param><key>value</key><value>150</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>400000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_address</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>system_time_granularity_us</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_mode_ms</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_device_address</value></param>
<param><key>value</key><value>"addr=10.0.0.9"</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>constellation</value></param>
<param><key>label</key><value>Constellation</value></param>
<param><key>value</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import gnuradio</value></param>
</block>
<block>
<key>inets_carrier_sensing</key>
<param><key>id</key><value>inets_carrier_sensing_0</value></param>
<param><key>block_id</key><value>111</value></param>
<param><key>rx_sensitivity_dB</key><value>15</value></param>
<param><key>nf_initial_n</key><value>100</value></param>
<param><key>comment</key><value>CCA1 in pool carrier sensing</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>cs_duration</key><value>60</value></param>
<param><key>cs_mode</key><value>2</value></param>
<param><key>show_fail</key><value>0</value></param>
<param><key>reset_duration</key><value>0</value></param>
<param><key>show_stop</key><value>1</value></param>
<param><key>show_thre</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>cs_threshold</key><value>0.005</value></param>
</block>
<block>
<key>inets_carrier_sensing</key>
<param><key>id</key><value>inets_carrier_sensing_0_0</value></param>
<param><key>block_id</key><value>13</value></param>
<param><key>rx_sensitivity_dB</key><value>15</value></param>
<param><key>nf_initial_n</key><value>100</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>cs_duration</key><value>CCA2_ms</value></param>
<param><key>cs_mode</key><value>2</value></param>
<param><key>show_fail</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>show_stop</key><value>1</value></param>
<param><key>show_thre</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>cs_threshold</key><value>0.005</value></param>
</block>
<block>
<key>inets_carrier_sensing</key>
<param><key>id</key><value>inets_carrier_sensing_0_1</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>rx_sensitivity_dB</key><value>15</value></param>
<param><key>nf_initial_n</key><value>100</value></param>
<param><key>comment</key><value>CCA1 before transmission</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>cs_duration</key><value>500</value></param>
<param><key>cs_mode</key><value>2</value></param>
<param><key>show_fail</key><value>0</value></param>
<param><key>reset_duration</key><value>0</value></param>
<param><key>show_stop</key><value>1</value></param>
<param><key>show_thre</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>cs_threshold</key><value>0.005</value></param>
</block>
<block>
<key>inets_cogmac_ch_pool</key>
<param><key>id</key><value>inets_cogmac_ch_pool_0</value></param>
<param><key>algorithm</key><value>0</value></param>
<param><key>block_id</key><value>35</value></param>
<param><key>channel_gap</key><value>10000000</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>first_channel</key><value>350000000</value></param>
<param><key>channel_number</key><value>ch_pool_size</value></param>
</block>
<block>
<key>inets_cogmac_rm_rep</key>
<param><key>id</key><value>inets_cogmac_rm_rep_0</value></param>
<param><key>block_id</key><value>37</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>new</key><value>0</value></param>
<param><key>same</key><value>1</value></param>
</block>
<block>
<key>inets_cogmac_timing</key>
<param><key>id</key><value>inets_cogmac_timing_0</value></param>
<param><key>block_id</key><value>37</value></param>
<param><key>CCA2_ms</key><value>CCA2_ms</value></param>
<param><key>ch_pool_size</key><value>ch_pool_size</value></param>
<param><key>ch_switch_ms</key><value>ch_switch_ms</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>frame_length</key><value>frame_length</value></param>
<param><key>inter_fr_ms</key><value>inter_fr_ms</value></param>
<param><key>len_mac_hdr</key><value>15</value></param>
<param><key>N_Mul_Fr</key><value>N_Mul_Fr</value></param>
<param><key>len_phy_overhead</key><value>148</value></param>
<param><key>PU_time_ms</key><value>PU_time_ms</value></param>
<param><key>padding</key><value>64</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>rx_mode_ms</key><value>rx_mode_ms</value></param>
<param><key>reset_N_Mul_Fr_Ctrl</key><value>0</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>tx_mode_ms</key><value>tx_mode_ms</value></param>
<param><key>bps</key><value>constellation.bits_per_symbol() * (samp_rate / sps)</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>100</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"cogmac_tx_pool4_cca30"</value></param>
<param><key>record_on</key><value>1</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>name_with_stamp</key><value>0</value></param>
</block>
<block>
<key>inets_dummy_source</key>
<param><key>id</key><value>inets_dummy_source_0</value></param>
<param><key>block_id</key><value>23</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>packet_rate</key><value>1</value></param>
<param><key>payload_length</key><value>frame_length</value></param>
<param><key>show</key><value>0</value></param>
<param><key>source_type</key><value>3</value></param>
</block>
<block>
<key>inets_frame_analysis</key>
<param><key>id</key><value>inets_frame_analysis_0</value></param>
<param><key>apply_self_address_check</key><value>1</value></param>
<param><key>block_id</key><value>7</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>my_address</key><value>source_address</value></param>
</block>
<block>
<key>inets_frame_and</key>
<param><key>id</key><value>inets_frame_and_0_0</value></param>
<param><key>block_id</key><value>38</value></param>
<param><key>comment</key><value>and tx buffer is ready</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>force_out</key><value>1</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>output_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_buffer</key>
<param><key>id</key><value>inets_frame_buffer_0</value></param>
<param><key>auto_dequeue_first</key><value>0</value></param>
<param><key>auto_dequeue_full</key><value>1</value></param>
<param><key>block_id</key><value>15</value></param>
<param><key>buffer_size</key><value>10</value></param>
<param><key>keep_dequeue_state</key><value>0</value></param>
<param><key>dequeue</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>enqueue</key><value>0</value></param>
<param><key>flush</key><value>1</value></param>
<param><key>show_empty</key><value>1</value></param>
<param><key>show_full</key><value>1</value></param>
<param><key>indicate</key><value>1</value></param>
<param><key>output_empty</key><value>0</value></param>
<param><key>reset_size</key><value>0</value></param>
</block>
<block>
<key>inets_frame_buffer</key>
<param><key>id</key><value>inets_frame_buffer_0_0</value></param>
<param><key>auto_dequeue_first</key><value>0</value></param>
<param><key>auto_dequeue_full</key><value>0</value></param>
<param><key>block_id</key><value>16</value></param>
<param><key>buffer_size</key><value>13</value></param>
<param><key>keep_dequeue_state</key><value>0</value></param>
<param><key>dequeue</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>enqueue</key><value>0</value></param>
<param><key>flush</key><value>1</value></param>
<param><key>show_empty</key><value>1</value></param>
<param><key>show_full</key><value>0</value></param>
<param><key>indicate</key><value>1</value></param>
<param><key>output_empty</key><value>1</value></param>
<param><key>reset_size</key><value>0</value></param>
</block>
<block>
<key>inets_frame_buffer</key>
<param><key>id</key><value>inets_frame_buffer_0_0_0</value></param>
<param><key>auto_dequeue_first</key><value>1</value></param>
<param><key>auto_dequeue_full</key><value>0</value></param>
<param><key>block_id</key><value>16</value></param>
<param><key>buffer_size</key><value>100</value></param>
<param><key>keep_dequeue_state</key><value>1</value></param>
<param><key>dequeue</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>enqueue</key><value>0</value></param>
<param><key>flush</key><value>0</value></param>
<param><key>show_empty</key><value>1</value></param>
<param><key>show_full</key><value>1</value></param>
<param><key>indicate</key><value>1</value></param>
<param><key>output_empty</key><value>1</value></param>
<param><key>reset_size</key><value>1</value></param>
</block>
<block>
<key>inets_frame_check</key>
<param><key>id</key><value>inets_frame_check_0</value></param>
<param><key>block_id</key><value>9</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_bad_frame</key><value>1</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
</block>
<block>
<key>inets_frame_counter</key>
<param><key>id</key><value>inets_frame_counter_0</value></param>
<param><key>block_id</key><value>36</value></param>
<param><key>comment</key><value>count for CCA1</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>counts</key><value>ch_pool_size</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>set</key><value>1</value></param>
<param><key>unselect</key><value>0</value></param>
</block>
<block>
<key>inets_frame_counter</key>
<param><key>id</key><value>inets_frame_counter_1</value></param>
<param><key>block_id</key><value>36</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>counts</key><value>4</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>set</key><value>0</value></param>
<param><key>unselect</key><value>0</value></param>
</block>
<block>
<key>inets_frame_counter</key>
<param><key>id</key><value>inets_frame_counter_2</value></param>
<param><key>block_id</key><value>36</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>counts</key><value>121</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>set</key><value>1</value></param>
<param><key>unselect</key><value>0</value></param>
</block>
<block>
<key>inets_frame_index_selector</key>
<param><key>id</key><value>inets_frame_index_selector_0</value></param>
<param><key>block_id</key><value>33</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_selected</key><value>0</value></param>
<param><key>output_unselected</key><value>0</value></param>
<param><key>selected_index</key><value>10</value></param>
<param><key>reset_selection</key><value>0</value></param>
</block>
<block>
<key>inets_frame_index_selector</key>
<param><key>id</key><value>inets_frame_index_selector_0_0</value></param>
<param><key>block_id</key><value>33</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_selected</key><value>1</value></param>
<param><key>output_unselected</key><value>0</value></param>
<param><key>selected_index</key><value>1</value></param>
<param><key>reset_selection</key><value>1</value></param>
</block>
<block>
<key>inets_frame_index_selector</key>
<param><key>id</key><value>inets_frame_index_selector_0_0_0</value></param>
<param><key>block_id</key><value>33</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_selected</key><value>1</value></param>
<param><key>output_unselected</key><value>0</value></param>
<param><key>selected_index</key><value>10</value></param>
<param><key>reset_selection</key><value>0</value></param>
</block>
<block>
<key>inets_frame_index_selector</key>
<param><key>id</key><value>inets_frame_index_selector_0_1</value></param>
<param><key>block_id</key><value>33</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_selected</key><value>0</value></param>
<param><key>output_unselected</key><value>1</value></param>
<param><key>selected_index</key><value>1</value></param>
<param><key>reset_selection</key><value>1</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_1</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_1_0_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>comment</key><value>resume CCA_CH</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_1_0_0_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>comment</key><value>CCA2 busy</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_1_0_0_1</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>comment</key><value>resume CCA1</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_1_0_0_1_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_1_1</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_1_1_0_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_1_1_0_0_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_1_1_0_0_1</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>comment</key><value>start CCA1</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_1_1_0_0_1_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>comment</key><value>testing</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_2</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_2_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_3_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_0</value></param>
<param><key>block_id</key><value>100</value></param>
<param><key>cs_threshold</key><value>0.001</value></param>
<param><key>cs_mode</key><value>0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>enable_new_name</key><value>1</value></param>
<param><key>file_name_extension</key><value>"CogMAC_pool2"</value></param>
<param><key>output_time_info</key><value>1</value></param>
<param><key>print_frame</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_stamp</key><value>0</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_0_1</value></param>
<param><key>block_id</key><value>99</value></param>
<param><key>cs_threshold</key><value>0.001</value></param>
<param><key>cs_mode</key><value>0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>enable_new_name</key><value>1</value></param>
<param><key>file_name_extension</key><value>""</value></param>
<param><key>output_time_info</key><value>1</value></param>
<param><key>print_frame</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_1</value></param>
<param><key>block_id</key><value>999</value></param>
<param><key>cs_threshold</key><value>0.01</value></param>
<param><key>cs_mode</key><value>0</value></param>
<param><key>develop_mode</key><value>2</value></param>
<param><key>enable_new_name</key><value>1</value></param>
<param><key>file_name_extension</key><value>""</value></param>
<param><key>output_time_info</key><value>1</value></param>
<param><key>print_frame</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_frame_redundancy_remover</key>
<param><key>id</key><value>inets_frame_redundancy_remover_0</value></param>
<param><key>block_id</key><value>49</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_re</key><value>1</value></param>
</block>
<block>
<key>inets_frame_replicate</key>
<param><key>id</key><value>inets_frame_replicate_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>show_complete</key><value>0</value></param>
<param><key>replicate_number</key><value>4</value></param>
<param><key>reset_number_replicate</key><value>0</value></param>
</block>
<block>
<key>inets_framing</key>
<param><key>id</key><value>inets_framing_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>default_payload_length</key><value>300</value></param>
<param><key>destination_address</key><value>destination_address</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>frame_type</key><value>1</value></param>
<param><key>increase_index</key><value>-1</value></param>
<param><key>frame_index</key><value>10</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_slot_time_beacon</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>node_list</key><value>[2, 3]</value></param>
<param><key>output_frame_pmt</key><value>1</value></param>
<param><key>reserved_field_I</key><value>318</value></param>
<param><key>reserved_field_II</key><value>524</value></param>
<param><key>reserved_field_ampdu</key><value>0</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>show_reset_index</key><value>0</value></param>
<param><key>show_reset_initial_index</key><value>0</value></param>
<param><key>slot_list_ms</key><value>[1000, 1000]</value></param>
<param><key>source_address</key><value>source_address</value></param>
<param><key>default_payload</key><value>0</value></param>
<param><key>internal_index</key><value>1</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_0</value></param>
<param><key>block_id</key><value>5</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>20</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_1</value></param>
<param><key>block_id</key><value>3</value></param>
<param><key>comment</key><value>ch_switch_ms</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>ch_switch_ms</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_1_0</value></param>
<param><key>block_id</key><value>3</value></param>
<param><key>comment</key><value>ch_switch_ms</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>ch_switch_ms</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_2</value></param>
<param><key>block_id</key><value>3</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>200</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_2_0</value></param>
<param><key>block_id</key><value>3</value></param>
<param><key>comment</key><value>prolong rx</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>100</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_3</value></param>
<param><key>block_id</key><value>3</value></param>
<param><key>comment</key><value>CCA2</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>rx_mode_ms</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_4</value></param>
<param><key>block_id</key><value>5</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>60000</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>0</value></param>
</block>
<block>
<key>inets_parameter_list</key>
<param><key>id</key><value>inets_parameter_list_0</value></param>
<param><key>block_id</key><value>49</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>output_n</key><value>1</value></param>
<param><key>list</key><value>[25,25,25,25,25,25,25,25,25,25,23,23,23,23,23,23,23,23,23,23,21,21,21,21,21,21,21,21,21,21,19,19,19,19,19,19,19,19,19,19,17,17,17,17,17,17,17,17,17,17,15,15,15,15,15,15,15,15,15,15,13,13,13,13,13,13,13,13,13,13,11,11,11,11,11,11,11,11,11,11,9,9,9,9,9,9,9,9,9,9,7,7,7,7,7,7,7,7,7,7,5,5,5,5,5,5,5,5,5,5,3,3,3,3,3,3,3,3,3,3]</value></param>
</block>
<block>
<key>inets_receiving</key>
<param><key>id</key><value>inets_receiving_0</value></param>
<param><key>block_id</key><value>21</value></param>
<param><key>center_frequency</key><value>center_frequency</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>reset_rf</key><value>0</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>mu</key><value>mu</value></param>
<param><key>output_rss</key><value>0</value></param>
<param><key>output_rx_switch</key><value>0</value></param>
<param><key>output_snr</key><value>1</value></param>
<param><key>output_rx_frame</key><value>0</value></param>
<param><key>rx_gain</key><value>rx_gain</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold</key><value>30</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>matched_filter_coeff</key><value>rrc</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>usrp_device_address</key><value>usrp_device_address</value></param>
</block>
<block>
<key>inets_run</key>
<param><key>id</key><value>inets_run_0</value></param>
<param><key>start_next_time_s</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
</block>
<block>
<key>inets_sending</key>
<param><key>id</key><value>inets_sending_0</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>center_frequency</key><value>center_frequency</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>reset</key><value>0</value></param>
<param><key>interframe_interval_s</key><value>inter_fr_ms / 1000</value></param>
<param><key>file_name_extension_pending</key><value>"Tfr"</value></param>
<param><key>file_name_extension_t_control</key><value>"t1TXs"</value></param>
<param><key>name_with_timestamp</key><value>1</value></param>
<param><key>t_pretx_interval_s</key><value>0</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>ack_frame</key><value>1</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>cts_frame</key><value>1</value></param>
<param><key>data_frame</key><value>0</value></param>
<param><key>rts_frame</key><value>1</value></param>
<param><key>rx_control</key><value>0</value></param>
<param><key>unknown_frame</key><value>1</value></param>
<param><key>tx_gain</key><value>0</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>usrp_device_address</key><value>usrp_device_address</value></param>
</block>
<block>
<key>inets_unbundle</key>
<param><key>id</key><value>inets_unbundle_0</value></param>
<param><key>block_id</key><value>16</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>command_name</key><value>N_Re_fr</value></param>
</block>
<block>
<key>inets_unbundle</key>
<param><key>id</key><value>inets_unbundle_0_0</value></param>
<param><key>block_id</key><value>16</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>command_name</key><value>N_PU</value></param>
</block>
<block>
<key>inets_unbundle</key>
<param><key>id</key><value>inets_unbundle_0_0_0</value></param>
<param><key>block_id</key><value>16</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>command_name</key><value>CCA1_ms</value></param>
</block>
<block>
<key>inets_unbundle</key>
<param><key>id</key><value>inets_unbundle_0_0_0_0</value></param>
<param><key>block_id</key><value>16</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>command_name</key><value>N_Fr</value></param>
</block>
<block>
<key>inets_unbundle</key>
<param><key>id</key><value>inets_unbundle_0_0_0_0_0</value></param>
<param><key>block_id</key><value>16</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>command_name</key><value>N_Mul_Fr</value></param>
</block>
<connection><source_block_id>inets_carrier_sensing_0</source_block_id><sink_block_id>inets_general_timer_2_0</sink_block_id><source_key>cmd_fail_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0</source_block_id><sink_block_id>inets_frame_counter_0</sink_block_id><source_key>cmd_pass_out</source_key><sink_key>counts_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0_0</source_block_id><sink_block_id>inets_frame_path_1_0_0_0</sink_block_id><source_key>cmd_fail_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0_0</source_block_id><sink_block_id>inets_general_timer_2_0</sink_block_id><source_key>cmd_fail_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0_0</source_block_id><sink_block_id>inets_frame_path_1_0_0_1_0</sink_block_id><source_key>cmd_pass_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0_1</source_block_id><sink_block_id>inets_general_timer_2_0</sink_block_id><source_key>cmd_fail_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0_1</source_block_id><sink_block_id>inets_frame_and_0_0</sink_block_id><source_key>cmd_pass_out</source_key><sink_key>frame_I_in</sink_key></connection>
<connection><source_block_id>inets_cogmac_ch_pool_0</source_block_id><sink_block_id>inets_frame_path_1_0_0_1</sink_block_id><source_key>CCA_CH_f_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_cogmac_ch_pool_0</source_block_id><sink_block_id>inets_general_timer_1</sink_block_id><source_key>CCA_CH_f_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_cogmac_ch_pool_0</source_block_id><sink_block_id>inets_frame_path_1_0_0_1</sink_block_id><source_key>CCA_one_f_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_cogmac_ch_pool_0</source_block_id><sink_block_id>inets_general_timer_1_0</sink_block_id><source_key>CCA_one_f_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_cogmac_rm_rep_0</source_block_id><sink_block_id>inets_frame_probe_0_1</sink_block_id><source_key>new_cmd_out</source_key><sink_key>info_in</sink_key></connection>
<connection><source_block_id>inets_cogmac_timing_0</source_block_id><sink_block_id>inets_frame_path_1_1_0_0_1_0</sink_block_id><source_key>cmd_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_cogmac_timing_0</source_block_id><sink_block_id>inets_general_timer_0</sink_block_id><source_key>cmd_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_cogmac_timing_0</source_block_id><sink_block_id>inets_unbundle_0</sink_block_id><source_key>cogmac_config_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_cogmac_timing_0</source_block_id><sink_block_id>inets_unbundle_0_0</sink_block_id><source_key>cogmac_config_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_cogmac_timing_0</source_block_id><sink_block_id>inets_unbundle_0_0_0</sink_block_id><source_key>cogmac_config_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_cogmac_timing_0</source_block_id><sink_block_id>inets_unbundle_0_0_0_0</sink_block_id><source_key>cogmac_config_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_cogmac_timing_0</source_block_id><sink_block_id>inets_unbundle_0_0_0_0_0</sink_block_id><source_key>cogmac_config_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_dummy_source_0</source_block_id><sink_block_id>inets_framing_0</sink_block_id><source_key>output</source_key><sink_key>data_in</sink_key></connection>
<connection><source_block_id>inets_frame_analysis_0</source_block_id><sink_block_id>inets_frame_check_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_and_0_0</source_block_id><sink_block_id>inets_frame_buffer_0_0</sink_block_id><source_key>frame_out</source_key><sink_key>dequeue</sink_key></connection>
<connection><source_block_id>inets_frame_and_0_0</source_block_id><sink_block_id>inets_framing_0</sink_block_id><source_key>frame_out</source_key><sink_key>reset_index</sink_key></connection>
<connection><source_block_id>inets_frame_buffer_0</source_block_id><sink_block_id>inets_frame_path_0</sink_block_id><source_key>buffer_not_full</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_buffer_0</source_block_id><sink_block_id>inets_frame_index_selector_0</sink_block_id><source_key>dequeue_element</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_buffer_0</source_block_id><sink_block_id>inets_frame_index_selector_0_0</sink_block_id><source_key>dequeue_element</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_buffer_0_0</source_block_id><sink_block_id>inets_frame_and_0_0</sink_block_id><source_key>buffer_full</source_key><sink_key>frame_II_in</sink_key></connection>
<connection><source_block_id>inets_frame_buffer_0_0</source_block_id><sink_block_id>inets_frame_buffer_0_0_0</sink_block_id><source_key>dequeue_element</source_key><sink_key>enqueue</sink_key></connection>
<connection><source_block_id>inets_frame_buffer_0_0</source_block_id><sink_block_id>inets_frame_path_1_1</sink_block_id><source_key>dequeue_element</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_buffer_0_0_0</source_block_id><sink_block_id>inets_frame_counter_1</sink_block_id><source_key>dequeue_element</source_key><sink_key>counts_in</sink_key></connection>
<connection><source_block_id>inets_frame_check_0</source_block_id><sink_block_id>inets_cogmac_rm_rep_0</sink_block_id><source_key>good_frame_info_out</source_key><sink_key>frame_cmd_in</sink_key></connection>
<connection><source_block_id>inets_frame_check_0</source_block_id><sink_block_id>inets_general_timer_2_0</sink_block_id><source_key>good_frame_info_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_frame_counter_0</source_block_id><sink_block_id>inets_frame_path_1_1_0_0</sink_block_id><source_key>select_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_counter_0</source_block_id><sink_block_id>inets_frame_path_1_1_0_0_1</sink_block_id><source_key>select_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_counter_0</source_block_id><sink_block_id>inets_frame_path_1_0_0</sink_block_id><source_key>unselect_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_counter_1</source_block_id><sink_block_id>inets_frame_path_1_1_0_0_0</sink_block_id><source_key>select_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_counter_1</source_block_id><sink_block_id>inets_general_timer_3</sink_block_id><source_key>select_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_frame_counter_1</source_block_id><sink_block_id>inets_frame_path_1_0_0_1_0</sink_block_id><source_key>unselect_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_counter_2</source_block_id><sink_block_id>inets_counter_0</sink_block_id><source_key>select_out</source_key><sink_key>reset_counter</sink_key></connection>
<connection><source_block_id>inets_frame_counter_2</source_block_id><sink_block_id>inets_dummy_source_0</sink_block_id><source_key>select_out</source_key><sink_key>stop_in</sink_key></connection>
<connection><source_block_id>inets_frame_counter_2</source_block_id><sink_block_id>inets_counter_0</sink_block_id><source_key>unselect_out</source_key><sink_key>reset_counter</sink_key></connection>
<connection><source_block_id>inets_frame_counter_2</source_block_id><sink_block_id>inets_general_timer_4</sink_block_id><source_key>unselect_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_frame_index_selector_0</source_block_id><sink_block_id>inets_frame_replicate_0</sink_block_id><source_key>frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_index_selector_0</source_block_id><sink_block_id>inets_frame_path_1</sink_block_id><source_key>unselected_frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_index_selector_0_0</source_block_id><sink_block_id>inets_frame_index_selector_0_0_0</sink_block_id><source_key>unselected_frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_index_selector_0_0_0</source_block_id><sink_block_id>inets_frame_buffer_0</sink_block_id><source_key>unselected_frame_out</source_key><sink_key>dequeue</sink_key></connection>
<connection><source_block_id>inets_frame_index_selector_0_1</source_block_id><sink_block_id>inets_general_timer_2</sink_block_id><source_key>frame_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_0</source_block_id><sink_block_id>inets_dummy_source_0</sink_block_id><source_key>frame_out</source_key><sink_key>trigger</sink_key></connection>
<connection><source_block_id>inets_frame_path_1</source_block_id><sink_block_id>inets_frame_buffer_0_0</sink_block_id><source_key>frame_out</source_key><sink_key>enqueue</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_0_0</source_block_id><sink_block_id>inets_frame_path_1_1_0_0_1_0</sink_block_id><source_key>frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_0_0_0</source_block_id><sink_block_id>inets_frame_buffer_0_0_0</sink_block_id><source_key>frame_out</source_key><sink_key>flush</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_0_0_1</source_block_id><sink_block_id>inets_receiving_0</sink_block_id><source_key>frame_out</source_key><sink_key>reconfig_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_0_0_1</source_block_id><sink_block_id>inets_sending_0</sink_block_id><source_key>frame_out</source_key><sink_key>reconfig_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_0_0_1_0</source_block_id><sink_block_id>inets_receiving_0</sink_block_id><source_key>frame_out</source_key><sink_key>rx_switch_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_1</source_block_id><sink_block_id>inets_frame_buffer_0_0</sink_block_id><source_key>frame_out</source_key><sink_key>dequeue</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_1_0_0</source_block_id><sink_block_id>inets_frame_counter_0</sink_block_id><source_key>frame_out</source_key><sink_key>reset_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_1_0_0_0</source_block_id><sink_block_id>inets_frame_counter_1</sink_block_id><source_key>frame_out</source_key><sink_key>reset_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_1_0_0_1</source_block_id><sink_block_id>inets_cogmac_ch_pool_0</sink_block_id><source_key>frame_out</source_key><sink_key>CCA_one_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_1_1_0_0_1_0</source_block_id><sink_block_id>inets_cogmac_ch_pool_0</sink_block_id><source_key>frame_out</source_key><sink_key>CCA_CH_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_2</source_block_id><sink_block_id>inets_frame_buffer_0_0_0</sink_block_id><source_key>frame_out</source_key><sink_key>dequeue</sink_key></connection>
<connection><source_block_id>inets_frame_path_2_0</source_block_id><sink_block_id>inets_frame_counter_1</sink_block_id><source_key>frame_out</source_key><sink_key>reset_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_3_0</source_block_id><sink_block_id>inets_parameter_list_0</sink_block_id><source_key>frame_out</source_key><sink_key>trigger_in</sink_key></connection>
<connection><source_block_id>inets_frame_redundancy_remover_0</source_block_id><sink_block_id>inets_counter_0</sink_block_id><source_key>cmd_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_frame_replicate_0</source_block_id><sink_block_id>inets_frame_buffer_0</sink_block_id><source_key>complete_out</source_key><sink_key>dequeue</sink_key></connection>
<connection><source_block_id>inets_frame_replicate_0</source_block_id><sink_block_id>inets_frame_path_1</sink_block_id><source_key>replicate_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_framing_0</source_block_id><sink_block_id>inets_frame_buffer_0</sink_block_id><source_key>frame_out</source_key><sink_key>enqueue</sink_key></connection>
<connection><source_block_id>inets_general_timer_0</source_block_id><sink_block_id>inets_dummy_source_0</sink_block_id><source_key>expire_signal_out</source_key><sink_key>trigger</sink_key></connection>
<connection><source_block_id>inets_general_timer_1</source_block_id><sink_block_id>inets_carrier_sensing_0</sink_block_id><source_key>expire_signal_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_1_0</source_block_id><sink_block_id>inets_carrier_sensing_0_1</sink_block_id><source_key>expire_signal_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_2</source_block_id><sink_block_id>inets_frame_path_0</sink_block_id><source_key>expire_signal_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_2</source_block_id><sink_block_id>inets_frame_path_1_1_0_0_1_0</sink_block_id><source_key>expire_signal_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_2</source_block_id><sink_block_id>inets_frame_path_2_0</sink_block_id><source_key>expire_signal_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_2_0</source_block_id><sink_block_id>inets_frame_path_1_0_0</sink_block_id><source_key>expire_signal_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_3</source_block_id><sink_block_id>inets_carrier_sensing_0_0</sink_block_id><source_key>expire_signal_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_4</source_block_id><sink_block_id>inets_frame_counter_2</sink_block_id><source_key>expire_signal_out</source_key><sink_key>counts_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_4</source_block_id><sink_block_id>inets_parameter_list_0</sink_block_id><source_key>expire_signal_out</source_key><sink_key>trigger_in</sink_key></connection>
<connection><source_block_id>inets_parameter_list_0</source_block_id><sink_block_id>inets_cogmac_timing_0</sink_block_id><source_key>parameter_out</source_key><sink_key>reset_N_Mul_Fr_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0</source_block_id><sink_block_id>inets_frame_analysis_0</sink_block_id><source_key>rx_frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0</source_block_id><sink_block_id>inets_carrier_sensing_0</sink_block_id><source_key>rx_power_out</source_key><sink_key>power_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0</source_block_id><sink_block_id>inets_carrier_sensing_0_0</sink_block_id><source_key>rx_power_out</source_key><sink_key>power_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0</source_block_id><sink_block_id>inets_carrier_sensing_0_1</sink_block_id><source_key>rx_power_out</source_key><sink_key>power_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0</source_block_id><sink_block_id>inets_sending_0</sink_block_id><source_key>rx_switch_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_run_0</source_block_id><sink_block_id>inets_cogmac_timing_0</sink_block_id><source_key>trigger_out</source_key><sink_key>trigger_in</sink_key></connection>
<connection><source_block_id>inets_run_0</source_block_id><sink_block_id>inets_frame_path_3_0</sink_block_id><source_key>trigger_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_run_0</source_block_id><sink_block_id>inets_general_timer_4</sink_block_id><source_key>trigger_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_sending_0</source_block_id><sink_block_id>inets_frame_index_selector_0_1</sink_block_id><source_key>data_frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_sending_0</source_block_id><sink_block_id>inets_frame_probe_0</sink_block_id><source_key>data_frame_out</source_key><sink_key>info_in</sink_key></connection>
<connection><source_block_id>inets_sending_0</source_block_id><sink_block_id>inets_frame_redundancy_remover_0</sink_block_id><source_key>data_frame_out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_sending_0</source_block_id><sink_block_id>inets_frame_path_2</sink_block_id><source_key>rx_control_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_sending_0</source_block_id><sink_block_id>inets_receiving_0</sink_block_id><source_key>rx_control_out</source_key><sink_key>rx_switch_in</sink_key></connection>
<connection><source_block_id>inets_unbundle_0</source_block_id><sink_block_id>inets_frame_replicate_0</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_number_in</sink_key></connection>
<connection><source_block_id>inets_unbundle_0_0</source_block_id><sink_block_id>inets_frame_counter_1</sink_block_id><source_key>cmd_out</source_key><sink_key>set_n_counts_in</sink_key></connection>
<connection><source_block_id>inets_unbundle_0_0_0</source_block_id><sink_block_id>inets_carrier_sensing_0</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_duration_in</sink_key></connection>
<connection><source_block_id>inets_unbundle_0_0_0</source_block_id><sink_block_id>inets_carrier_sensing_0_1</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_duration_in</sink_key></connection>
<connection><source_block_id>inets_unbundle_0_0_0_0</source_block_id><sink_block_id>inets_frame_buffer_0_0</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_size_in</sink_key></connection>
<connection><source_block_id>inets_unbundle_0_0_0_0_0</source_block_id><sink_block_id>inets_frame_buffer_0</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_size_in</sink_key></connection>
<connection><source_block_id>inets_unbundle_0_0_0_0_0</source_block_id><sink_block_id>inets_frame_index_selector_0</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_index_in</sink_key></connection>
<connection><source_block_id>inets_unbundle_0_0_0_0_0</source_block_id><sink_block_id>inets_frame_index_selector_0_0_0</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_index_in</sink_key></connection>
<connection><source_block_id>inets_unbundle_0_0_0_0_0</source_block_id><sink_block_id>inets_framing_0</sink_block_id><source_key>cmd_out</source_key><sink_key>reset_initial_index</sink_key></connection>
</flow_graph>
