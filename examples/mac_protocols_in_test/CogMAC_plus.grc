<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>CogMAC_plus</value></param>
<param><key>author</key><value>PWA</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>CogMAC_plus</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cs_threshold</value></param>
<param><key>value</key><value>0.005</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_address</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>diff_preamble_128</value></param>
<param><key>value</key><value>[1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0,0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0,0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1,1, 1, 1, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 1, 0, 0][0:128]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mu</value></param>
<param><key>value</key><value>range_mu</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_mu</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>BB Derotation Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_rx_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Rx Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_center_frequency</value></param>
<param><key>value</key><value>3.9e8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>range_rx_gain</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_address</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>system_time_granularity_us</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_center_frequency</value></param>
<param><key>value</key><value>3.9e8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_device_address</value></param>
<param><key>value</key><value>"addr=10.0.0.20"</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import gnuradio</value></param>
</block>
<block>
<key>inets_dummy_source</key>
<param><key>id</key><value>inets_dummy_source_0</value></param>
<param><key>block_id</key><value>23</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>packet_rate</key><value>100</value></param>
<param><key>payload_length</key><value>100</value></param>
<param><key>source_type</key><value>1</value></param>
</block>
<block>
<key>inets_frame_and</key>
<param><key>id</key><value>inets_frame_and_0</value></param>
<param><key>block_id</key><value>38</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>force_out</key><value>1</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>output_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_buffer</key>
<param><key>id</key><value>inets_frame_buffer_0</value></param>
<param><key>auto_dequeue_first</key><value>0</value></param>
<param><key>auto_dequeue_full</key><value>1</value></param>
<param><key>block_id</key><value>16</value></param>
<param><key>buffer_size</key><value>4</value></param>
<param><key>keep_dequeue_state</key><value>0</value></param>
<param><key>dequeue</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>enqueue</key><value>0</value></param>
<param><key>flush</key><value>1</value></param>
<param><key>indicate</key><value>0</value></param>
<param><key>output_empty</key><value>0</value></param>
<param><key>show_empty</key><value>0</value></param>
</block>
<block>
<key>inets_frame_buffer</key>
<param><key>id</key><value>inets_frame_buffer_0_0</value></param>
<param><key>auto_dequeue_first</key><value>0</value></param>
<param><key>auto_dequeue_full</key><value>0</value></param>
<param><key>block_id</key><value>16</value></param>
<param><key>buffer_size</key><value>100</value></param>
<param><key>keep_dequeue_state</key><value>0</value></param>
<param><key>dequeue</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>enqueue</key><value>0</value></param>
<param><key>flush</key><value>1</value></param>
<param><key>indicate</key><value>1</value></param>
<param><key>output_empty</key><value>1</value></param>
<param><key>show_empty</key><value>0</value></param>
</block>
<block>
<key>inets_frame_index_selector</key>
<param><key>id</key><value>inets_frame_index_selector_0</value></param>
<param><key>block_id</key><value>33</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_unselected</key><value>0</value></param>
<param><key>selected_index</key><value>4</value></param>
</block>
<block>
<key>inets_frame_index_selector</key>
<param><key>id</key><value>inets_frame_index_selector_1</value></param>
<param><key>block_id</key><value>33</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_unselected</key><value>0</value></param>
<param><key>selected_index</key><value>1</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_0_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_0_0_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_0_0_1</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_0_0_1_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_0_0_1_1</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_0_0_2</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_probe</key>
<param><key>id</key><value>inets_frame_probe_0</value></param>
<param><key>block_id</key><value>100</value></param>
<param><key>cs_threshold</key><value>0.01</value></param>
<param><key>cs_mode</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>print_frame</key><value>0</value></param>
</block>
<block>
<key>inets_frame_replicate</key>
<param><key>id</key><value>inets_frame_replicate_0</value></param>
<param><key>block_id</key><value>37</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>replicate_number</key><value>4</value></param>
<param><key>reset_number_replicate</key><value>1</value></param>
</block>
<block>
<key>inets_framing</key>
<param><key>id</key><value>inets_framing_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>default_payload_length</key><value>300</value></param>
<param><key>destination_address</key><value>destination_address</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>frame_type</key><value>1</value></param>
<param><key>increase_index</key><value>-1</value></param>
<param><key>frame_index</key><value>4</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_slot_time_beacon</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>node_list</key><value>[2, 3]</value></param>
<param><key>output_frame_pmt</key><value>1</value></param>
<param><key>reserved_field_I</key><value>318</value></param>
<param><key>reserved_field_II</key><value>524</value></param>
<param><key>reserved_field_ampdu</key><value>0</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>show_reset_index</key><value>0</value></param>
<param><key>slot_list_ms</key><value>[1000, 1000]</value></param>
<param><key>source_address</key><value>source_address</value></param>
<param><key>default_payload</key><value>0</value></param>
<param><key>internal_index</key><value>1</value></param>
</block>
<block>
<key>inets_sending</key>
<param><key>id</key><value>inets_sending_0</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>center_frequency</key><value>tx_center_frequency</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>interframe_interval_s</key><value>0.005</value></param>
<param><key>t_pretx_interval_s</key><value>0.003</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>ack_frame</key><value>1</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>cts_frame</key><value>1</value></param>
<param><key>data_frame</key><value>0</value></param>
<param><key>rts_frame</key><value>1</value></param>
<param><key>rx_control</key><value>1</value></param>
<param><key>unknown_frame</key><value>1</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>usrp_device_address</key><value>usrp_device_address</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>inets_frame_buffer_0</sink_block_id><source_key>strobe</source_key><sink_key>indicate_empty</sink_key></connection>
<connection><source_block_id>inets_dummy_source_0</source_block_id><sink_block_id>inets_framing_0</sink_block_id><source_key>output</source_key><sink_key>data_in</sink_key></connection>
<connection><source_block_id>inets_frame_and_0</source_block_id><sink_block_id>inets_frame_path_0_0_1</sink_block_id><source_key>frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_buffer_0</source_block_id><sink_block_id>inets_frame_path_0_0_0</sink_block_id><source_key>buffer_empty</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_buffer_0</source_block_id><sink_block_id>inets_frame_path_0_0</sink_block_id><source_key>buffer_not_full</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_buffer_0</source_block_id><sink_block_id>inets_frame_index_selector_0</sink_block_id><source_key>dequeue_element</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_buffer_0_0</source_block_id><sink_block_id>inets_frame_and_0</sink_block_id><source_key>buffer_empty</source_key><sink_key>frame_II_in</sink_key></connection>
<connection><source_block_id>inets_frame_buffer_0_0</source_block_id><sink_block_id>inets_sending_0</sink_block_id><source_key>dequeue_element</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_frame_index_selector_0</source_block_id><sink_block_id>inets_frame_replicate_0</sink_block_id><source_key>frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_index_selector_0</source_block_id><sink_block_id>inets_frame_index_selector_1</sink_block_id><source_key>unselected_frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_index_selector_0</source_block_id><sink_block_id>inets_frame_path_0</sink_block_id><source_key>unselected_frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_index_selector_1</source_block_id><sink_block_id>inets_frame_buffer_0_0</sink_block_id><source_key>frame_out</source_key><sink_key>dequeue</sink_key></connection>
<connection><source_block_id>inets_frame_index_selector_1</source_block_id><sink_block_id>inets_frame_path_0_0_1_1</sink_block_id><source_key>frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_index_selector_1</source_block_id><sink_block_id>inets_frame_path_0_0_1_1</sink_block_id><source_key>unselected_frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_0</source_block_id><sink_block_id>inets_frame_buffer_0</sink_block_id><source_key>frame_out</source_key><sink_key>dequeue</sink_key></connection>
<connection><source_block_id>inets_frame_path_0_0</source_block_id><sink_block_id>inets_dummy_source_0</sink_block_id><source_key>frame_out</source_key><sink_key>trigger</sink_key></connection>
<connection><source_block_id>inets_frame_path_0_0_0</source_block_id><sink_block_id>inets_framing_0</sink_block_id><source_key>frame_out</source_key><sink_key>reset_index</sink_key></connection>
<connection><source_block_id>inets_frame_path_0_0_1</source_block_id><sink_block_id>inets_frame_buffer_0</sink_block_id><source_key>frame_out</source_key><sink_key>indicate_empty</sink_key></connection>
<connection><source_block_id>inets_frame_path_0_0_1_0</source_block_id><sink_block_id>inets_frame_buffer_0_0</sink_block_id><source_key>frame_out</source_key><sink_key>dequeue</sink_key></connection>
<connection><source_block_id>inets_frame_path_0_0_1_1</source_block_id><sink_block_id>inets_frame_buffer_0_0</sink_block_id><source_key>frame_out</source_key><sink_key>enqueue</sink_key></connection>
<connection><source_block_id>inets_frame_path_0_0_2</source_block_id><sink_block_id>inets_frame_buffer_0</sink_block_id><source_key>frame_out</source_key><sink_key>dequeue</sink_key></connection>
<connection><source_block_id>inets_frame_replicate_0</source_block_id><sink_block_id>inets_frame_path_0_0_2</sink_block_id><source_key>complete_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_replicate_0</source_block_id><sink_block_id>inets_frame_buffer_0_0</sink_block_id><source_key>replicate_out</source_key><sink_key>enqueue</sink_key></connection>
<connection><source_block_id>inets_framing_0</source_block_id><sink_block_id>inets_frame_buffer_0</sink_block_id><source_key>frame_out</source_key><sink_key>enqueue</sink_key></connection>
<connection><source_block_id>inets_sending_0</source_block_id><sink_block_id>inets_frame_and_0</sink_block_id><source_key>data_frame_out</source_key><sink_key>frame_I_in</sink_key></connection>
<connection><source_block_id>inets_sending_0</source_block_id><sink_block_id>inets_frame_path_0_0_1_0</sink_block_id><source_key>data_frame_out</source_key><sink_key>frame_in</sink_key></connection>
</flow_graph>
