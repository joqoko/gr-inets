<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>receive_frame</value></param>
<param><key>author</key><value>PWA</value></param>
<param><key>category</key><value>inets_dmf_mac</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>receive_frame</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>k</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>polys</value></param>
<param><key>value</key><value>[109, 79]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>apply_address_check</value></param>
<param><key>label</key><value>apply_address_check</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>block_id</value></param>
<param><key>label</key><value>block_id</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0_0_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0_0_0_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>constellation</value></param>
<param><key>label</key><value>Constellation</value></param>
<param><key>value</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>develop_mode</value></param>
<param><key>label</key><value>develop_mode</value></param>
<param><key>value</key><value>[11]</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import gnuradio</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>inets_address_check_cpp</key>
<param><key>id</key><value>inets_address_check_cpp_1</value></param>
<param><key>apply_address_check</key><value>apply_address_check</value></param>
<param><key>block_id</key><value>block_id</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>my_address</key><value>my_address</value></param>
</block>
<block>
<key>inets_frame_header_analysis_cpp</key>
<param><key>id</key><value>inets_frame_header_analysis_cpp_1</value></param>
<param><key>apply_address_check</key><value>apply_address_check</value></param>
<param><key>block_id</key><value>block_id</value></param>
<param><key>develop_mode</key><value>2</value></param>
<param><key>len_destination_address</key><value>len_destination_address</value></param>
<param><key>len_frame_index</key><value>len_frame_index</value></param>
<param><key>len_frame_type</key><value>len_frame_type</value></param>
<param><key>len_num_transmission</key><value>len_num_transmission</value></param>
<param><key>len_payload_length</key><value>len_payload_length</value></param>
<param><key>len_reserved_field_I</key><value>len_reserved_field_I</value></param>
<param><key>len_reserved_field_II</key><value>len_reserved_field_II</value></param>
<param><key>len_source_address</key><value>len_source_address</value></param>
<param><key>my_address</key><value>my_address</value></param>
</block>
<block>
<key>inets_frame_verification_cpp</key>
<param><key>id</key><value>inets_frame_verification_cpp_0</value></param>
<param><key>block_id</key><value>block_id</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>len_destination_address</value></param>
<param><key>label</key><value>len_destination_address</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>len_frame_index</value></param>
<param><key>label</key><value>len_frame_index</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>len_frame_type</value></param>
<param><key>label</key><value>len_frame_type</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>len_num_transmission</value></param>
<param><key>label</key><value>len_num_transmission</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>len_payload_length</value></param>
<param><key>label</key><value>len_payload_length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>len_reserved_field_I</value></param>
<param><key>label</key><value>len_reserved_field_I</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>len_reserved_field_II</value></param>
<param><key>label</key><value>len_reserved_field_II</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>len_source_address</value></param>
<param><key>label</key><value>len_source_address</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>matched_filter_coeff</value></param>
<param><key>label</key><value>matched_filter</value></param>
<param><key>value</key><value>()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mu</value></param>
<param><key>label</key><value>Mu</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>my_address</value></param>
<param><key>label</key><value>my_address</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>payload_const</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>correlation</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>RX Constellation</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble</value></param>
<param><key>label</key><value>preamble</value></param>
<param><key>value</key><value>()</value></param>
</block>
<block>
<key>receive_frame_phy</key>
<param><key>id</key><value>receive_frame_phy_0</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>mu</key><value>mu</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>rx_gain</key><value>rx_gain</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>block_id</key><value>3</value></param>
<param><key>matched_filter_coeff</key><value>matched_filter_coeff</value></param>
<param><key>preamble</key><value>preamble</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>rx_frame_info_out</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>rx_frame_info_out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>label</key><value>RX gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>rx_power_out</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>rx_power_out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>rx_switch_in</value></param>
<param><key>label</key><value>rx_switch_in</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Samples per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold</value></param>
<param><key>label</key><value>Preamble Detector Threshold</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>4e8</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>usrp_device_address</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>usrp_device_address</value></param>
<param><key>label</key><value>USRP device address</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"addr=10.0.0.6"</value></param>
</block>
<connection><source_block_id>inets_address_check_cpp_1</source_block_id><sink_block_id>inets_frame_verification_cpp_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_header_analysis_cpp_1</source_block_id><sink_block_id>inets_address_check_cpp_1</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_verification_cpp_0</source_block_id><sink_block_id>rx_frame_info_out</sink_block_id><source_key>frame_info_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>receive_frame_phy_0</source_block_id><sink_block_id>blocks_null_sink_0_0_0_0_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>receive_frame_phy_0</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>receive_frame_phy_0</source_block_id><sink_block_id>blocks_null_sink_0_0_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>receive_frame_phy_0</source_block_id><sink_block_id>pad_sink_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>receive_frame_phy_0</source_block_id><sink_block_id>blocks_null_sink_0_0_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>receive_frame_phy_0</source_block_id><sink_block_id>inets_frame_header_analysis_cpp_1</sink_block_id><source_key>out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>receive_frame_phy_0</source_block_id><sink_block_id>blocks_null_sink_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>receive_frame_phy_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>receive_frame_phy_0</source_block_id><sink_block_id>rx_power_out</sink_block_id><source_key>rx_power_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>rx_switch_in</source_block_id><sink_block_id>receive_frame_phy_0</sink_block_id><source_key>out</source_key><sink_key>rx_switch_in</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>receive_frame_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
