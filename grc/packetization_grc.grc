<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>packetization_grc</value></param>
<param><key>author</key><value>PWA</value></param>
<param><key>category</key><value>inets_dmf_mac</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>packetization_grc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>block_id</value></param>
<param><key>label</key><value>block_id</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>31</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.6</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>constellation.bits_per_symbol()</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>c</key><value>sps</value></param>
<param><key>lengthtagname</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>constellation</value></param>
<param><key>label</key><value>Constellation</value></param>
<param><key>value</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>develop_mode</value></param>
<param><key>label</key><value>develop mode</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>digital_burst_shaper_xx</key>
<param><key>id</key><value>digital_burst_shaper_xx_0</value></param>
<param><key>insert_phasing</key><value>False</value></param>
<param><key>length_tag_name</key><value>"packet_len"</value></param>
<param><key>post_padding</key><value>0</value></param>
<param><key>pre_padding</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>window</key><value>gnuradio.fft.window.hanning(1024)</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>constellation.points()</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import gnuradio</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>inets_decouple_frame_info</key>
<param><key>id</key><value>inets_decouple_frame_info_0</value></param>
<param><key>block_id</key><value>block_id</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_message_tomb</key>
<param><key>id</key><value>inets_message_tomb_0</value></param>
</block>
<block>
<key>inets_packetizer</key>
<param><key>id</key><value>inets_packetizer_0</value></param>
<param><key>bps</key><value>constellation.bits_per_symbol() * (samp_rate / sps)</value></param>
<param><key>block_id</key><value>block_id</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>padding</key><value>64</value></param>
<param><key>preamble</key><value>preamble</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>packet_out</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>packet_out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble</value></param>
<param><key>label</key><value>preamble</value></param>
<param><key>value</key><value>[]</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>0.8</value></param>
<param><key>type</key><value>interp_fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>interp</key><value>sps</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Samplerate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Samples per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>system_time_granularity_us</value></param>
<param><key>label</key><value>system time granularity us</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>digital_burst_shaper_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>packet_out</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_burst_shaper_xx_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inets_decouple_frame_info_0</source_block_id><sink_block_id>inets_message_tomb_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_decouple_frame_info_0</source_block_id><sink_block_id>inets_packetizer_0</sink_block_id><source_key>frame_pmt_out</source_key><sink_key>payload_in</sink_key></connection>
<connection><source_block_id>inets_packetizer_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>packet_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>inets_decouple_frame_info_0</sink_block_id><source_key>out</source_key><sink_key>frame_cluster_in</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
