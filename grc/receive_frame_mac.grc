<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>receive_frame_mac</value></param>
<param><key>author</key><value>pwa</value></param>
<param><key>category</key><value>inets_dmf_v1.0</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>receive_frame_mac</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>apply_address_check</value></param>
<param><key>label</key><value>apply_address_check</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>develop_mode</value></param>
<param><key>label</key><value>develop_mode</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>frame_from_phy</value></param>
<param><key>label</key><value>frame_from_phy</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>inets_address_check_cpp</key>
<param><key>id</key><value>inets_address_check_cpp_0</value></param>
<param><key>apply_address_check</key><value>apply_address_check</value></param>
<param><key>block_id</key><value>8</value></param>
<param><key>develop_mode</key><value>develop_mode</value></param>
<param><key>my_address</key><value>my_address</value></param>
</block>
<block>
<key>inets_frame_header_analysis_cpp</key>
<param><key>id</key><value>inets_frame_header_analysis_cpp_0</value></param>
<param><key>apply_address_check</key><value>apply_address_check</value></param>
<param><key>block_id</key><value>7</value></param>
<param><key>develop_mode</key><value>develop_mode</value></param>
<param><key>len_destination_address</key><value>len_destination_address</value></param>
<param><key>len_frame_index</key><value>len_frame_index</value></param>
<param><key>len_frame_type</key><value>len_frame_type</value></param>
<param><key>len_num_transmission</key><value>len_num_transmission</value></param>
<param><key>len_payload_length</key><value>len_payload_length</value></param>
<param><key>len_reserved_field_I</key><value>len_reserved_field_I</value></param>
<param><key>len_reserved_field_II</key><value>len_reserved_field_II</value></param>
<param><key>len_source_address</key><value>len_source_address</value></param>
</block>
<block>
<key>inets_frame_verification_cpp</key>
<param><key>id</key><value>inets_frame_verification_cpp_0</value></param>
<param><key>develop_mode_list</key><value>develop_mode_list</value></param>
</block>
<block>
<key>inets_message_tomb</key>
<param><key>id</key><value>inets_message_tomb_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>len_destination_address</value></param>
<param><key>label</key><value>len_destination_address</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>len_frame_index</value></param>
<param><key>label</key><value>len_frame_index</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>len_frame_type</value></param>
<param><key>label</key><value>len_frame_type</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>len_num_transmission</value></param>
<param><key>label</key><value>len_num_transmission</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>len_payload_length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>len_reserved_field_I</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>len_reserved_field_II</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>len_source_address</value></param>
<param><key>label</key><value>len_source_address</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>my_address</value></param>
<param><key>label</key><value>my_address</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>rx_frame_info_out</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>rx_frame_info_out</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>samp_rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<connection><source_block_id>frame_from_phy</source_block_id><sink_block_id>inets_frame_header_analysis_cpp_0</sink_block_id><source_key>out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_address_check_cpp_0</source_block_id><sink_block_id>inets_frame_verification_cpp_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_address_check_cpp_0</source_block_id><sink_block_id>rx_frame_info_out</sink_block_id><source_key>frame_info_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_frame_header_analysis_cpp_0</source_block_id><sink_block_id>inets_address_check_cpp_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_header_analysis_cpp_0</source_block_id><sink_block_id>inets_message_tomb_0</sink_block_id><source_key>frame_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_frame_verification_cpp_0</source_block_id><sink_block_id>rx_frame_info_out</sink_block_id><source_key>frame_info_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_frame_verification_cpp_0</source_block_id><sink_block_id>inets_message_tomb_0</sink_block_id><source_key>good_frame</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_frame_verification_cpp_0</source_block_id><sink_block_id>inets_message_tomb_0</sink_block_id><source_key>payload_out</source_key><sink_key>message_in</sink_key></connection>
</flow_graph>
